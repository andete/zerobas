; Copyright (c) 2026 Joost Yervante Damad
; SPDX-License-Identifier: 0BSD
;
; XKEY -- docs/bios/DSPFNK.md round 1 (2026-11-17): DSPFNK ($00CF), ERAFNK ($00CC) and FNKSB ($00C9) on the
; VG-8020 against zerobas. The CASE TABLE at the end is GENERATED by probes/bios/spec/xkey_cases.py (--gen), whose
; docstring documents the separating setup and the 129-byte record; the same module decodes the run.
; Run: python3 -u probes/bios/biosl_run.py probes/bios/spec/xkey.asm --row nodisk
; The capture: CAP+1 = $A5 when finished; records from CAP+2.
;
; CLEAN-ROOM: 100% own code; only published BIOS entries and work-area cells; VRAM through RDVRM / FILVRM.
;
; @cap C000
; @caplen 1730
; @timeout 300

RDVRM   equ     $004A
FILVRM  equ     $0056
INITXT  equ     $006C
INIT32  equ     $006F
INIGRP  equ     $0072
LINL40  equ     $F3AE
LINL32  equ     $F3AF
LINLEN  equ     $F3B0
CRTCNT  equ     $F3B1
CSRY    equ     $F3DC
CSRX    equ     $F3DD
CNSDFG  equ     $F3DE
SCRMOD  equ     $FCAF
FNKSTR  equ     $F87F
FNKFLG  equ     $FBCE

DONE    equ     $C000
CAP     equ     $C001
CAPLEN  equ     5936
ptr     equ     $EF00
tptr    equ     $EF02
ccall   equ     $EF04
cmode   equ     $EF05
cwidth  equ     $EF06
ccns    equ     $EF07
ccrt    equ     $EF08
cflg    equ     $EF09
clab    equ     $EF0A
nbase   equ     $EF10
ncols   equ     $EF12

                org     $4000
                db      "AB"
                dw      init, 0, 0, 0
                ds      6, 0

init:
                ld      hl, CAP
                ld      de, CAP+1
                ld      bc, CAPLEN - 1
                ld      (hl), 0
                ldir
                ld      hl, CAP+2
                ld      (ptr), hl
                ld      hl, cases
                ld      (tptr), hl
next:
                ld      hl, (tptr)
                ld      a, (hl)
                cp      $FF
                jp      z, finish
                ld      de, ccall
                ld      bc, 7
                ldir
                ld      (tptr), hl
                ; the screen, key line off: INITXT / INIT32 / INIGRP
                xor     a
                ld      (CNSDFG), a
                ld      a, 24
                ld      (CRTCNT), a
                ld      a, (cwidth)
                ld      (LINL40), a
                ld      (LINL32), a
                ld      a, (cmode)
                or      a
                jr      nz, m_1
                call    INITXT
                ld      hl, 0
                ld      a, 40
                jr      m_done
m_1:
                cp      1
                jr      nz, m_2
                call    INIT32
                jr      m_32
m_2:
                call    INIGRP
m_32:
                ld      hl, $1800
                ld      a, 32
m_done:
                ld      (nbase), hl
                ld      (ncols), a
                ; separate LINLEN from the width cells
                ld      a, 77
                ld      (LINL40), a
                ld      (LINL32), a
                ; the labels
                ld      hl, keys
                ld      a, (clab)
                or      a
                jr      z, l_def
                ld      hl, keys2
l_def:
                ld      de, FNKSTR
                ld      bc, 160
                ldir
                ; FNKFLG x 10
                ld      hl, FNKFLG
                ld      a, (cflg)
                ld      b, 10
f_lp:
                ld      (hl), a
                inc     hl
                djnz    f_lp
                ld      a, (ccrt)
                ld      (CRTCNT), a
                ld      a, (ccns)
                ld      (CNSDFG), a
                ; garbage: the name table $5A, the cursor
                ld      hl, (nbase)
                ld      bc, 960
                ld      a, (ncols)
                cp      40
                jr      z, g_nb
                ld      bc, 768
g_nb:
                ld      a, $5A
                call    FILVRM
                ld      a, 7
                ld      (CSRX), a
                ld      a, 5
                ld      (CSRY), a
                ; the call under test
                ld      hl, (ccall)
                ld      h, 0
                call    jphl
                ; the record
                ld      a, (CNSDFG)
                call    emit
                ld      a, (CRTCNT)
                call    emit
                ld      a, (CSRX)
                call    emit
                ld      a, (CSRY)
                call    emit
                ld      a, (LINLEN)
                call    emit
                ld      a, (SCRMOD)
                call    emit
                ld      hl, (nbase)
                ld      bc, 960
                ld      a, (ncols)
                cp      40
                jr      z, r_nb
                ld      bc, 768
r_nb:
                call    vsum
                ld      a, 24
                call    row40
                ld      a, (ccrt)
                call    row40
                ld      a, (ccrt)
                dec     a
                call    row40
                ld      a, $C3                  ; the record's sentinel
                call    emit
                jp      next

finish:
                ld      a, $A5
                ld      (CAP+1), a
                ld      (DONE), a
halt_lp:
                jr      halt_lp

jphl:
                jp      (hl)

; row40 -- emit 40 VRAM cells from the start of row A (1-based): nbase + (A-1) x ncols
row40:
                ld      hl, (nbase)
                ld      b, a
                dec     b
                jr      z, rw_go
                ld      a, (ncols)
                ld      e, a
                ld      d, 0
rw_mul:
                add     hl, de
                djnz    rw_mul
rw_go:
                ld      b, 40
rw_lp:
                push    bc
                push    hl
                call    RDVRM
                call    emit
                pop     hl
                pop     bc
                inc     hl
                djnz    rw_lp
                ret

; vsum -- emit sum16 (low, high) of BC VRAM bytes from HL
vsum:
                ld      de, 0
vs_lp:
                push    bc
                push    de
                push    hl
                call    RDVRM
                pop     hl
                pop     de
                add     a, e
                ld      e, a
                jr      nc, vs_nc
                inc     d
vs_nc:
                pop     bc
                inc     hl
                dec     bc
                ld      a, b
                or      c
                jr      nz, vs_lp
                ld      a, e
                call    emit
                ld      a, d
                jp      emit

emit:
                push    hl
                ld      hl, (ptr)
                ld      (hl), a
                inc     hl
                ld      (ptr), hl
                pop     hl
                ret

keys:
                db      "key0", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key1", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key2", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key3", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key4", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key5", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key6", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key7", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key8", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key9", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
; odd labels: 15 characters; a $01 graphic prefix; a CR; empty; DEL + ESC Y; then "k5".."k9"
keys2:
                db      "abcdefghijklmno", 0
                db      $01, "Ab", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "a", $0D, "b", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                ds      16, 0
                db      $7F, $1B, "Y", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "k5", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "k6", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "k7", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "k8", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "k9", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0

; ---- GENERATED by xkey_cases.py --gen: call, mode, width, CNSDFG, CRTCNT, FNKFLG, labels; $FF ends ----
cases:
                db      $CF, 0, 40, 0, 24, 0, 0   ; DSPFNK SCREEN 0 width 40 CNSDFG 0 CRTCNT 24
                db      $CF, 0, 40, 1, 24, 0, 0   ; DSPFNK SCREEN 0 width 40 CNSDFG 1 CRTCNT 24
                db      $CF, 0, 40, 128, 24, 0, 0   ; DSPFNK SCREEN 0 width 40 CNSDFG 128 CRTCNT 24
                db      $CF, 0, 37, 1, 24, 0, 0   ; DSPFNK SCREEN 0 width 37 CNSDFG 1 CRTCNT 24
                db      $CF, 0, 39, 1, 24, 0, 0   ; DSPFNK SCREEN 0 width 39 CNSDFG 1 CRTCNT 24
                db      $CF, 1, 32, 0, 24, 0, 0   ; DSPFNK SCREEN 1 width 32 CNSDFG 0 CRTCNT 24
                db      $CF, 1, 32, 1, 24, 0, 0   ; DSPFNK SCREEN 1 width 32 CNSDFG 1 CRTCNT 24
                db      $CF, 1, 29, 0, 24, 0, 0   ; DSPFNK SCREEN 1 width 29 CNSDFG 0 CRTCNT 24
                db      $CF, 1, 29, 1, 24, 0, 0   ; DSPFNK SCREEN 1 width 29 CNSDFG 1 CRTCNT 24
                db      $CF, 0, 40, 0, 13, 0, 0   ; DSPFNK SCREEN 0 width 40 CNSDFG 0 CRTCNT 13
                db      $CF, 2, 32, 0, 24, 0, 0   ; DSPFNK SCREEN 2 width 32 CNSDFG 0 CRTCNT 24
                db      $CF, 0, 40, 1, 13, 0, 0   ; DSPFNK SCREEN 0 width 40 CNSDFG 1 CRTCNT 13
                db      $CF, 2, 32, 1, 24, 0, 0   ; DSPFNK SCREEN 2 width 32 CNSDFG 1 CRTCNT 24
                db      $CC, 0, 40, 0, 24, 0, 0   ; ERAFNK SCREEN 0 width 40 CNSDFG 0 CRTCNT 24
                db      $CC, 0, 40, 1, 24, 0, 0   ; ERAFNK SCREEN 0 width 40 CNSDFG 1 CRTCNT 24
                db      $CC, 0, 40, 128, 24, 0, 0   ; ERAFNK SCREEN 0 width 40 CNSDFG 128 CRTCNT 24
                db      $CC, 0, 37, 1, 24, 0, 0   ; ERAFNK SCREEN 0 width 37 CNSDFG 1 CRTCNT 24
                db      $CC, 0, 39, 1, 24, 0, 0   ; ERAFNK SCREEN 0 width 39 CNSDFG 1 CRTCNT 24
                db      $CC, 1, 32, 0, 24, 0, 0   ; ERAFNK SCREEN 1 width 32 CNSDFG 0 CRTCNT 24
                db      $CC, 1, 32, 1, 24, 0, 0   ; ERAFNK SCREEN 1 width 32 CNSDFG 1 CRTCNT 24
                db      $CC, 1, 29, 0, 24, 0, 0   ; ERAFNK SCREEN 1 width 29 CNSDFG 0 CRTCNT 24
                db      $CC, 1, 29, 1, 24, 0, 0   ; ERAFNK SCREEN 1 width 29 CNSDFG 1 CRTCNT 24
                db      $CC, 0, 40, 0, 13, 0, 0   ; ERAFNK SCREEN 0 width 40 CNSDFG 0 CRTCNT 13
                db      $CC, 2, 32, 0, 24, 0, 0   ; ERAFNK SCREEN 2 width 32 CNSDFG 0 CRTCNT 24
                db      $CC, 0, 40, 1, 13, 0, 0   ; ERAFNK SCREEN 0 width 40 CNSDFG 1 CRTCNT 13
                db      $CC, 2, 32, 1, 24, 0, 0   ; ERAFNK SCREEN 2 width 32 CNSDFG 1 CRTCNT 24
                db      $C9, 0, 40, 0, 24, 0, 0   ; FNKSB SCREEN 0 width 40 CNSDFG 0 CRTCNT 24
                db      $C9, 0, 40, 1, 24, 0, 0   ; FNKSB SCREEN 0 width 40 CNSDFG 1 CRTCNT 24
                db      $C9, 0, 40, 128, 24, 0, 0   ; FNKSB SCREEN 0 width 40 CNSDFG 128 CRTCNT 24
                db      $C9, 0, 37, 1, 24, 0, 0   ; FNKSB SCREEN 0 width 37 CNSDFG 1 CRTCNT 24
                db      $C9, 0, 39, 1, 24, 0, 0   ; FNKSB SCREEN 0 width 39 CNSDFG 1 CRTCNT 24
                db      $C9, 1, 32, 0, 24, 0, 0   ; FNKSB SCREEN 1 width 32 CNSDFG 0 CRTCNT 24
                db      $C9, 1, 32, 1, 24, 0, 0   ; FNKSB SCREEN 1 width 32 CNSDFG 1 CRTCNT 24
                db      $C9, 1, 29, 0, 24, 0, 0   ; FNKSB SCREEN 1 width 29 CNSDFG 0 CRTCNT 24
                db      $C9, 1, 29, 1, 24, 0, 0   ; FNKSB SCREEN 1 width 29 CNSDFG 1 CRTCNT 24
                db      $C9, 0, 40, 0, 13, 0, 0   ; FNKSB SCREEN 0 width 40 CNSDFG 0 CRTCNT 13
                db      $C9, 2, 32, 0, 24, 0, 0   ; FNKSB SCREEN 2 width 32 CNSDFG 0 CRTCNT 24
                db      $C9, 0, 40, 1, 13, 0, 0   ; FNKSB SCREEN 0 width 40 CNSDFG 1 CRTCNT 13
                db      $C9, 2, 32, 1, 24, 0, 0   ; FNKSB SCREEN 2 width 32 CNSDFG 1 CRTCNT 24
                db      $C9, 0, 40, 0, 24, 1, 0   ; FNKSB SCREEN 0 width 40 CNSDFG 0 CRTCNT 24 FNKFLG 1
                db      $C9, 0, 40, 0, 24, 255, 0   ; FNKSB SCREEN 0 width 40 CNSDFG 0 CRTCNT 24 FNKFLG 255
                db      $C9, 0, 40, 1, 24, 1, 0   ; FNKSB SCREEN 0 width 40 CNSDFG 1 CRTCNT 24 FNKFLG 1
                db      $C9, 0, 40, 1, 24, 255, 0   ; FNKSB SCREEN 0 width 40 CNSDFG 1 CRTCNT 24 FNKFLG 255
                db      $CF, 0, 40, 0, 24, 0, 1   ; DSPFNK SCREEN 0 width 40 CNSDFG 0 CRTCNT 24 odd labels
                db      $CF, 1, 32, 0, 24, 0, 1   ; DSPFNK SCREEN 1 width 32 CNSDFG 0 CRTCNT 24 odd labels
                db      $CF, 0, 40, 1, 24, 0, 1   ; DSPFNK SCREEN 0 width 40 CNSDFG 1 CRTCNT 24 odd labels
                db      $FF
