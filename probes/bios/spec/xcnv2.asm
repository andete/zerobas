; Copyright (c) 2026 Joost Yervante Damad
; SPDX-License-Identifier: 0BSD
;
; XCNV2 -- docs/bios/CNVCHR.md round 2 (2026-11-17): CNVCHR ($00AB) with every register garbage unlike the inputs,
; GRPHED values with bits 2 / 5 / 7 set, entry flags beyond $00 / $FF, and the natural header-then-character
; sequence. The CASE TABLE at the end is GENERATED by probes/bios/spec/xcnv2_cases.py (--gen), whose docstring
; documents the setup and the 18-byte record; the same module decodes the run.
; Run: python3 -u probes/bios/biosl_run.py probes/bios/spec/xcnv2.asm --row nodisk
;
; CLEAN-ROOM: 100% own code; one published BIOS entry and work-area cells.
;
; @cap C000
; @caplen 03CE
; @timeout 120

CNVCHR  equ     $00AB
GRPHED  equ     $FCA6
WAREA   equ     $F380
SNAP    equ     $D000

DONE    equ     $C000
CAP     equ     $C001
CAPLEN  equ     974
ptr     equ     $EF00
tptr    equ     $EF02
cseq    equ     $EF04
ca      equ     $EF05
cg      equ     $EF06
cf      equ     $EF07
hlcell  equ     $EF10
cnt     equ     $EF12
callA   equ     $EF14
callF   equ     $EF15

                org     $4000
                db      "AB"
                dw      init, 0, 0, 0
                ds      6, 0

init:
                di
                ld      hl, CAP
                ld      de, CAP+1
                ld      bc, CAPLEN - 1
                ld      (hl), 0
                ldir
                ld      hl, CAP+2
                ld      (ptr), hl
                ld      hl, cases
                ld      (tptr), hl
next:
                ld      hl, (tptr)
                ld      a, (hl)
                cp      $FF
                jp      z, finish
                ld      de, cseq
                ld      bc, 4
                ldir
                ld      (tptr), hl
                ld      a, (cseq)
                or      a
                jr      z, one
                ; seq: CNVCHR($01) with GRPHED := 0, F := the case's
                xor     a
                ld      (GRPHED), a
                ld      a, 1
                ld      (callA), a
                ld      a, (cf)
                ld      (callF), a
                call    docall
                jr      second
one:
                ld      a, (cg)
                ld      (GRPHED), a
second:
                ld      a, (ca)
                ld      (callA), a
                ld      a, (cf)
                ld      (callF), a
                call    docall
                jp      next

; docall -- one CNVCHR call with A / F := callA / callF, GRPHED as it is, every other register garbage; one record
docall:
                ld      a, (GRPHED)             ; the HL byte: the OPPOSITE of GRPHED's zero-ness
                or      a
                ld      a, 1
                jr      z, d_hl
                xor     a
d_hl:
                ld      (hlcell), a
                ld      hl, WAREA
                ld      de, SNAP
                ld      bc, 3200
                ldir
                ld      a, (callA)
                ld      d, a
                ld      a, (callF)
                ld      e, a
                push    de
                ld      bc, $1357
                ld      de, $9BDF
                ld      hl, hlcell
                ld      ix, $4321
                ld      iy, $8765
                pop     af
                call    CNVCHR
                push    iy
                push    ix
                push    hl
                push    de
                push    bc
                push    af
                ld      a, i
                push    af
                di
                pop     bc                      ; C = LD A,I's flags
                ld      a, c
                ld      (cnt), a                ; (parked)
                ld      b, 6
d_regs:
                pop     hl
                ld      a, h
                call    emit
                ld      a, l
                call    emit
                djnz    d_regs
                ld      a, (GRPHED)
                call    emit
                ld      a, (hlcell)
                call    emit
                ld      a, (cnt)
                call    emit
                ; the work area compared, GRPHED excluded
                ld      hl, 0
                ld      (cnt), hl
                ld      hl, WAREA
                ld      de, SNAP
w_lp:
                ld      a, h
                cp      $FC
                jr      nz, w_cmp
                ld      a, l
                cp      $A6
                jr      z, w_next
w_cmp:
                ld      a, (de)
                cp      (hl)
                jr      z, w_next
                push    hl
                ld      hl, (cnt)
                inc     hl
                ld      (cnt), hl
                pop     hl
w_next:
                inc     de
                inc     hl
                ld      a, h
                or      l
                jr      nz, w_lp
                ld      a, (cnt)
                call    emit
                ld      a, (cnt+1)
                call    emit
                ld      a, $C3
                jp      emit

finish:
                ld      a, $A5
                ld      (CAP+1), a
                ld      (DONE), a
halt_lp:
                jr      halt_lp

emit:
                push    hl
                ld      hl, (ptr)
                ld      (hl), a
                inc     hl
                ld      (ptr), hl
                pop     hl
                ret

; ---- GENERATED by xcnv2_cases.py --gen: seq, A, GRPHED, F; $FF ends ----
cases:
                db      0, $01, $80, $00   ; A 01 GRPHED 80 F 00
                db      0, $40, $80, $00   ; A 40 GRPHED 80 F 00
                db      0, $5F, $80, $00   ; A 5F GRPHED 80 F 00
                db      0, $3F, $80, $00   ; A 3F GRPHED 80 F 00
                db      0, $60, $80, $00   ; A 60 GRPHED 80 F 00
                db      0, $01, $FF, $00   ; A 01 GRPHED FF F 00
                db      0, $40, $FF, $00   ; A 40 GRPHED FF F 00
                db      0, $5F, $FF, $00   ; A 5F GRPHED FF F 00
                db      0, $3F, $FF, $00   ; A 3F GRPHED FF F 00
                db      0, $60, $FF, $00   ; A 60 GRPHED FF F 00
                db      0, $01, $20, $00   ; A 01 GRPHED 20 F 00
                db      0, $40, $20, $00   ; A 40 GRPHED 20 F 00
                db      0, $5F, $20, $00   ; A 5F GRPHED 20 F 00
                db      0, $3F, $20, $00   ; A 3F GRPHED 20 F 00
                db      0, $60, $20, $00   ; A 60 GRPHED 20 F 00
                db      0, $01, $04, $00   ; A 01 GRPHED 04 F 00
                db      0, $40, $04, $00   ; A 40 GRPHED 04 F 00
                db      0, $5F, $04, $00   ; A 5F GRPHED 04 F 00
                db      0, $3F, $04, $00   ; A 3F GRPHED 04 F 00
                db      0, $60, $04, $00   ; A 60 GRPHED 04 F 00
                db      0, $01, $00, $01   ; A 01 GRPHED 00 F 01
                db      0, $40, $01, $01   ; A 40 GRPHED 01 F 01
                db      0, $60, $01, $01   ; A 60 GRPHED 01 F 01
                db      0, $01, $00, $40   ; A 01 GRPHED 00 F 40
                db      0, $40, $01, $40   ; A 40 GRPHED 01 F 40
                db      0, $60, $01, $40   ; A 60 GRPHED 01 F 40
                db      0, $01, $00, $41   ; A 01 GRPHED 00 F 41
                db      0, $40, $01, $41   ; A 40 GRPHED 01 F 41
                db      0, $60, $01, $41   ; A 60 GRPHED 01 F 41
                db      0, $01, $00, $80   ; A 01 GRPHED 00 F 80
                db      0, $40, $01, $80   ; A 40 GRPHED 01 F 80
                db      0, $60, $01, $80   ; A 60 GRPHED 01 F 80
                db      0, $01, $00, $04   ; A 01 GRPHED 00 F 04
                db      0, $40, $01, $04   ; A 40 GRPHED 01 F 04
                db      0, $60, $01, $04   ; A 60 GRPHED 01 F 04
                db      0, $01, $00, $10   ; A 01 GRPHED 00 F 10
                db      0, $40, $01, $10   ; A 40 GRPHED 01 F 10
                db      0, $60, $01, $10   ; A 60 GRPHED 01 F 10
                db      0, $01, $00, $55   ; A 01 GRPHED 00 F 55
                db      0, $40, $01, $55   ; A 40 GRPHED 01 F 55
                db      0, $60, $01, $55   ; A 60 GRPHED 01 F 55
                db      0, $01, $00, $AA   ; A 01 GRPHED 00 F AA
                db      0, $40, $01, $AA   ; A 40 GRPHED 01 F AA
                db      0, $60, $01, $AA   ; A 60 GRPHED 01 F AA
                db      1, $3F, $00, $00   ; CNVCHR(01) then CNVCHR(3F), GRPHED left by the first
                db      1, $40, $00, $00   ; CNVCHR(01) then CNVCHR(40), GRPHED left by the first
                db      1, $5F, $00, $00   ; CNVCHR(01) then CNVCHR(5F), GRPHED left by the first
                db      1, $60, $00, $00   ; CNVCHR(01) then CNVCHR(60), GRPHED left by the first
                db      1, $01, $00, $00   ; CNVCHR(01) then CNVCHR(01), GRPHED left by the first
                db      $FF
