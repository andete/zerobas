; Copyright (c) 2026 Joost Yervante Damad
; SPDX-License-Identifier: BSD-2-Clause
;
; XCHG2 -- docs/bios/CHGET.md round 2 (2026-11-17): CHGET ($009F) / CHSNS ($009C) with the flag readings separated,
; entry F independent of the interrupt choice, every register garbage, CNSDFG 1, and the whole work area compared. The
; CASE TABLE at the end is GENERATED by probes/bios/spec/xchg2_cases.py (--gen), whose docstring documents the setup
; and the 83-byte record; the same module decodes the run.
; Run: python3 -u probes/bios/biosl_run.py probes/bios/spec/xchg2.asm --row nodisk
;
; CLEAN-ROOM: 100% own code; only published BIOS entries and work-area cells; VRAM through RDVRM / FILVRM.
;
; @cap C000
; @caplen 048C
; @timeout 120

RDVRM   equ     $004A
FILVRM  equ     $0056
INITXT  equ     $006C
LINL40  equ     $F3AE
LINLEN  equ     $F3B0
CRTCNT  equ     $F3B1
CNSDFG  equ     $F3DE
CSRY    equ     $F3DC
CSRX    equ     $F3DD
CSRSW   equ     $FCA9
KEYBUF  equ     $FBF0
PUTPNT  equ     $F3F8
GETPNT  equ     $F3FA
WAREA   equ     $F380
SNAP    equ     $D000

DONE    equ     $C000
CAP     equ     $C001
CAPLEN  equ     1164
ptr     equ     $EF00
tptr    equ     $EF02
ccall   equ     $EF04                   ; the case's 11 bytes, in table order
cn      equ     $EF05
ccodes  equ     $EF06
coff    equ     $EF09
cf      equ     $EF0A
cei     equ     $EF0B
ccns    equ     $EF0C
cx      equ     $EF0D
cy      equ     $EF0E
jpstub  equ     $EF20
cnt     equ     $EF24
naddr   equ     $EF26

                org     $4000
                db      "AB"
                dw      init, 0, 0, 0
                ds      6, 0

init:
                ld      hl, CAP
                ld      de, CAP+1
                ld      bc, CAPLEN - 1
                ld      (hl), 0
                ldir
                ld      hl, CAP+2
                ld      (ptr), hl
                ld      hl, cases
                ld      (tptr), hl
next:
                ld      hl, (tptr)
                ld      a, (hl)
                cp      $FF
                jp      z, finish
                ld      de, ccall
                ld      bc, 11
                ldir
                ld      (tptr), hl
                ld      a, 40
                ld      (LINL40), a
                ld      a, 24
                ld      (CRTCNT), a
                ld      a, (ccns)
                ld      (CNSDFG), a
                call    INITXT
                di
                ld      a, 1
                ld      (CSRSW), a
                ld      hl, 0
                ld      bc, $4000
                ld      a, $5A
                call    FILVRM
                di
                ld      hl, KEYBUF
                ld      b, 40
g_kb:
                ld      (hl), $66
                inc     hl
                djnz    g_kb
                ld      a, $A5
                ld      (KEYBUF-1), a
                ld      (KEYBUF+40), a
                ld      a, (cx)
                ld      (CSRX), a
                ld      a, (cy)
                ld      (CSRY), a
                ; the buffer: n codes from KEYBUF + off, wrapping at 40
                ld      a, (coff)
                ld      c, a
                ld      hl, KEYBUF
                ld      e, a
                ld      d, 0
                add     hl, de
                ld      (GETPNT), hl
                ld      a, (cn)
                ld      b, a
                ld      ix, ccodes
                or      a
                jr      z, b_done
b_lp:
                ld      hl, KEYBUF
                ld      e, c
                ld      d, 0
                add     hl, de
                ld      a, (ix+0)
                ld      (hl), a
                inc     ix
                inc     c
                ld      a, c
                cp      40
                jr      nz, b_nw
                ld      c, 0
b_nw:
                djnz    b_lp
b_done:
                ld      hl, KEYBUF
                ld      e, c
                ld      d, 0
                add     hl, de
                ld      (PUTPNT), hl
                ; the work area, copied
                ld      hl, WAREA
                ld      de, SNAP
                ld      bc, 3200
                ldir
                ; the call: every register garbage, A $A7, F the case's, interrupts per cei
                ld      a, $C3
                ld      (jpstub), a
                ld      a, (ccall)
                ld      (jpstub+1), a
                xor     a
                ld      (jpstub+2), a
                ld      a, (cf)
                ld      e, a
                ld      d, $A7
                push    de
                ld      a, (cei)
                or      a
                jr      z, c_di
                ei
c_di:
                ld      bc, $1357
                ld      de, $9BDF
                ld      hl, $2468
                ld      ix, $4321
                ld      iy, $8765
                pop     af
                call    jpstub
                push    iy
                push    ix
                push    hl
                push    de
                push    bc
                push    af
                ld      a, i
                jp      pe, $+5                 ; off? read again: an interrupt accepted DURING `ld a,i` reads
                ld      a, i                    ; P/V 0 (the NMOS erratum, D-IFFREAD1)
                push    af
                di
                pop     bc                      ; C = LD A,I's flags
                ld      b, 6
r_regs:
                pop     hl
                ld      a, h
                call    emit
                ld      a, l
                call    emit
                djnz    r_regs
                ld      a, c
                call    emit
                ld      a, (GETPNT)
                call    emit
                ld      a, (PUTPNT)
                call    emit
                ld      a, (CSRX)
                call    emit
                ld      a, (CSRY)
                call    emit
                ld      a, (CSRSW)
                call    emit
                ld      a, (CNSDFG)
                call    emit
                ld      a, (LINLEN)
                call    emit
                ld      hl, KEYBUF
                ld      b, 40
r_kb:
                ld      a, (hl)
                call    emit
                inc     hl
                djnz    r_kb
                ld      a, (KEYBUF-1)
                call    emit
                ld      a, (KEYBUF+40)
                call    emit
                ld      hl, 0
                ld      bc, $4000
                call    vsum
                ; the work area compared, skipping GETPNT / PUTPNT, KEYBUF and the interrupt's cells
                ld      hl, 0
                ld      (cnt), hl
                ld      hl, (ptr)
                ld      (naddr), hl
                ld      de, 18
                add     hl, de
                ld      (ptr), hl
                ld      hl, WAREA
                ld      de, SNAP
w_lp:
                call    skip
                jr      z, w_next
                ld      a, (de)
                cp      (hl)
                jr      z, w_next
                push    hl
                push    de
                ld      de, (cnt)
                inc     de
                ld      (cnt), de
                ld      a, d
                or      a
                jr      nz, w_skp
                ld      a, e
                cp      9
                jr      nc, w_skp
                dec     a
                add     a, a
                add     a, 2
                ld      e, a
                ld      d, 0
                ld      ix, (naddr)
                add     ix, de
                pop     de
                pop     hl
                ld      (ix+0), l
                ld      (ix+1), h
                jr      w_next
w_skp:
                pop     de
                pop     hl
w_next:
                inc     de
                inc     hl
                ld      a, h
                or      l
                jr      nz, w_lp
                ld      ix, (naddr)
                ld      hl, (cnt)
                ld      (ix+0), l
                ld      (ix+1), h
                ld      a, $C3
                call    emit
                jp      next

; skip -- Z when HL is a cell the comparison ignores: GETPNT / PUTPNT ($F3F8-$F3FB), the interrupt's $F3F6-$F3F7 and
; $FC9E-$FCA2, KEYBUF ($FBF0-$FC17)
skip:
                ld      a, h
                cp      $F3
                jr      nz, sk_fb
                ld      a, l
                cp      $F6
                jr      c, sk_no
                cp      $FC
                jr      c, sk_yes
                jr      sk_no
sk_fb:
                cp      $FB
                jr      nz, sk_fc
                ld      a, l
                cp      $F0
                jr      c, sk_no
                jr      sk_yes
sk_fc:
                cp      $FC
                jr      nz, sk_no
                ld      a, l
                cp      $18
                jr      c, sk_yes
                cp      $9E
                jr      c, sk_no
                cp      $A3
                jr      c, sk_yes
sk_no:
                or      1                       ; NZ
                ret
sk_yes:
                xor     a                       ; Z
                ret

finish:
                ld      a, $A5
                ld      (CAP+1), a
                ld      (DONE), a
halt_lp:
                jr      halt_lp

; vsum -- emit sum16 (low, high) of BC VRAM bytes from HL
vsum:
                ld      de, 0
vs_lp:
                push    bc
                push    de
                push    hl
                call    RDVRM
                pop     hl
                pop     de
                add     a, e
                ld      e, a
                jr      nc, vs_nc
                inc     d
vs_nc:
                pop     bc
                inc     hl
                dec     bc
                ld      a, b
                or      c
                jr      nz, vs_lp
                ld      a, e
                call    emit
                ld      a, d
                jp      emit

emit:
                push    hl
                ld      hl, (ptr)
                ld      (hl), a
                inc     hl
                ld      (ptr), hl
                pop     hl
                ret

; ---- GENERATED by xchg2_cases.py --gen: call, n, code x 3, off, F, ei, CNSDFG, CSRX, CSRY; $FF ends ----
cases:
                db      $9F, 3, $41, $42, $43, 0, $00, 0, 0, 7, 5   ; CHGET n 3 off 0 F 00
                db      $9F, 1, $41, $00, $00, 10, $00, 0, 0, 7, 5   ; CHGET n 1 off 10 F 00
                db      $9F, 1, $41, $00, $00, 5, $00, 0, 0, 7, 5   ; CHGET n 1 off 5 F 00
                db      $9F, 2, $41, $42, $00, 20, $00, 0, 0, 7, 5   ; CHGET n 2 off 20 F 00
                db      $9F, 2, $41, $42, $00, 38, $00, 0, 0, 7, 5   ; CHGET n 2 off 38 F 00
                db      $9F, 1, $41, $00, $00, 23, $00, 0, 0, 7, 5   ; CHGET n 1 off 23 F 00
                db      $9F, 1, $41, $00, $00, 24, $00, 0, 0, 7, 5   ; CHGET n 1 off 24 F 00
                db      $9F, 1, $41, $00, $00, 0, $FF, 0, 0, 7, 5   ; CHGET n 1 off 0 F FF
                db      $9F, 1, $41, $00, $00, 0, $00, 1, 0, 7, 5   ; CHGET n 1 off 0 F 00 EI
                db      $9F, 1, $41, $00, $00, 0, $00, 0, 1, 1, 24   ; CHGET n 1 off 0 F 00 CNSDFG 1 cursor 1,24
                db      $9C, 3, $41, $42, $43, 0, $FF, 0, 0, 7, 5   ; CHSNS n 3 off 0 F FF
                db      $9C, 0, $00, $00, $00, 10, $FF, 1, 0, 7, 5   ; CHSNS n 0 off 10 F FF EI
                db      $9C, 1, $41, $00, $00, 23, $00, 0, 1, 1, 24   ; CHSNS n 1 off 23 F 00 CNSDFG 1 cursor 1,24
                db      $9C, 2, $41, $42, $00, 39, $00, 0, 0, 7, 5   ; CHSNS n 2 off 39 F 00
                db      $FF
