; Copyright (c) 2026 Joost Yervante Damad
; SPDX-License-Identifier: 0BSD
;
; XCHG -- docs/bios/CHGET.md round 1 (2026-11-17): CHGET ($009F) and CHSNS ($009C) on the VG-8020 against zerobas,
; with the key buffer filled by the probe. The CASE TABLE at the end is GENERATED by probes/bios/spec/xchg_cases.py
; (--gen), whose docstring documents the setup and the 19-byte record; the same module decodes the run.
; Run: python3 -u probes/bios/biosl_run.py probes/bios/spec/xchg.asm --row nodisk
; The capture: CAP+1 = $A5 when finished; records from CAP+2.
;
; CLEAN-ROOM: 100% own code; only published BIOS entries and work-area cells; VRAM through RDVRM / FILVRM.
;
; @cap C000
; @caplen 0191
; @timeout 120

RDVRM   equ     $004A
FILVRM  equ     $0056
INITXT  equ     $006C
INIGRP  equ     $0072
CNSDFG  equ     $F3DE
CSRY    equ     $F3DC
CSRX    equ     $F3DD
SCRMOD  equ     $FCAF
CSRSW   equ     $FCA9
KEYBUF  equ     $FBF0
PUTPNT  equ     $F3F8
GETPNT  equ     $F3FA

DONE    equ     $C000
CAP     equ     $C001
CAPLEN  equ     401
ptr     equ     $EF00
tptr    equ     $EF02
ccall   equ     $EF04
cn      equ     $EF05
ccodes  equ     $EF06
coff    equ     $EF09
ccsrsw  equ     $EF0A
cmode   equ     $EF0B
cei     equ     $EF0C
jpstub  equ     $EF20
rA      equ     $EF30
rF      equ     $EF31
rI      equ     $EF32

                org     $4000
                db      "AB"
                dw      init, 0, 0, 0
                ds      6, 0

init:
                ld      hl, CAP
                ld      de, CAP+1
                ld      bc, CAPLEN - 1
                ld      (hl), 0
                ldir
                ld      hl, CAP+2
                ld      (ptr), hl
                ld      hl, cases
                ld      (tptr), hl
next:
                ld      hl, (tptr)
                ld      a, (hl)
                cp      $FF
                jp      z, finish
                ld      de, ccall
                ld      bc, 9
                ldir
                ld      (tptr), hl
                ; the screen
                xor     a
                ld      (CNSDFG), a
                ld      a, (cmode)
                or      a
                jr      nz, m_2
                call    INITXT
                jr      m_done
m_2:
                call    INIGRP
m_done:
                di
                ld      a, (ccsrsw)
                ld      (CSRSW), a
                ; garbage: all of VRAM, the buffer, the cursor
                ld      hl, 0
                ld      bc, $4000
                ld      a, $5A
                call    FILVRM
                di
                ld      hl, KEYBUF
                ld      b, 40
g_kb:
                ld      (hl), $66
                inc     hl
                djnz    g_kb
                ld      a, 7
                ld      (CSRX), a
                ld      a, 5
                ld      (CSRY), a
                ; the buffer: n codes from KEYBUF + off, wrapping at 40
                ld      a, (coff)
                ld      c, a                    ; c = the running offset
                ld      hl, KEYBUF
                ld      e, a
                ld      d, 0
                add     hl, de
                ld      (GETPNT), hl
                ld      a, (cn)
                ld      b, a
                ld      ix, ccodes
                or      a
                jr      z, b_done
b_lp:
                ld      hl, KEYBUF
                ld      e, c
                ld      d, 0
                add     hl, de
                ld      a, (ix+0)
                ld      (hl), a
                inc     ix
                inc     c
                ld      a, c
                cp      40
                jr      nz, b_nw
                ld      c, 0
b_nw:
                djnz    b_lp
b_done:
                ld      hl, KEYBUF
                ld      e, c
                ld      d, 0
                add     hl, de
                ld      (PUTPNT), hl
                ; the call through a RAM JP, A garbage, interrupts as the case says
                ld      a, $C3
                ld      (jpstub), a
                ld      a, (ccall)
                ld      (jpstub+1), a
                xor     a
                ld      (jpstub+2), a
                ld      a, (cei)
                or      a
                jr      z, c_di
                ei
c_di:
                ld      a, $5A
                call    jpstub
                push    af
                ld      a, i                    ; P/V := IFF2
                jp      pe, $+5                 ; off? read again: an interrupt accepted DURING `ld a,i` reads
                ld      a, i                    ; P/V 0 (the NMOS erratum, D-IFFREAD1)
                push    af
                di
                pop     hl
                ld      a, l
                ld      (rI), a
                pop     hl
                ld      a, h
                ld      (rA), a
                ld      a, l
                ld      (rF), a
                ; the record
                ld      a, (rA)
                call    emit
                ld      a, (rF)
                call    emit
                ld      hl, (GETPNT)
                ld      a, l
                call    emit
                ld      a, h
                call    emit
                ld      hl, (PUTPNT)
                ld      a, l
                call    emit
                ld      a, h
                call    emit
                ld      a, (rI)
                call    emit
                ld      a, (CSRX)
                call    emit
                ld      a, (CSRY)
                call    emit
                ld      a, (CSRSW)
                call    emit
                ld      a, (SCRMOD)
                call    emit
                ld      a, (CNSDFG)
                call    emit
                ld      hl, KEYBUF
                ld      de, 0
                ld      b, 40
k_lp:
                ld      a, (hl)
                add     a, e
                ld      e, a
                jr      nc, k_nc
                inc     d
k_nc:
                inc     hl
                djnz    k_lp
                ld      a, e
                call    emit
                ld      a, d
                call    emit
                ld      hl, 0
                ld      bc, $4000
                call    vsum
                ; the cursor's cell (row 5, column 7) and the one right of it
                ld      hl, 166                 ; SCREEN 0: (5 - 1) x 40 + (7 - 1)
                ld      a, (cmode)
                or      a
                jr      z, c_cell
                ld      hl, $1800 + 134         ; SCREEN 2: $1800 + (5 - 1) x 32 + (7 - 1)
c_cell:
                push    hl
                call    RDVRM
                call    emit
                pop     hl
                inc     hl
                call    RDVRM
                call    emit
                ld      a, $C3                  ; the record's sentinel
                call    emit
                jp      next

finish:
                ld      a, $A5
                ld      (CAP+1), a
                ld      (DONE), a
                ei
halt_lp:
                jr      halt_lp

; vsum -- emit sum16 (low, high) of BC VRAM bytes from HL
vsum:
                ld      de, 0
vs_lp:
                push    bc
                push    de
                push    hl
                call    RDVRM
                pop     hl
                pop     de
                add     a, e
                ld      e, a
                jr      nc, vs_nc
                inc     d
vs_nc:
                pop     bc
                inc     hl
                dec     bc
                ld      a, b
                or      c
                jr      nz, vs_lp
                ld      a, e
                call    emit
                ld      a, d
                jp      emit

emit:
                push    hl
                ld      hl, (ptr)
                ld      (hl), a
                inc     hl
                ld      (ptr), hl
                pop     hl
                ret

; ---- GENERATED by xchg_cases.py --gen: call, n, code x 3, off, CSRSW, mode, ei; $FF ends ----
cases:
                db      $9F, 1, $41, $00, $00, 0, 0, 0, 0   ; CHGET n 1 codes 41 off 0 CSRSW 0 SCREEN 0
                db      $9F, 1, $41, $00, $00, 0, 0, 0, 1   ; CHGET n 1 codes 41 off 0 CSRSW 0 SCREEN 0 EI
                db      $9F, 1, $41, $00, $00, 0, 1, 0, 0   ; CHGET n 1 codes 41 off 0 CSRSW 1 SCREEN 0
                db      $9F, 1, $41, $00, $00, 0, 1, 0, 1   ; CHGET n 1 codes 41 off 0 CSRSW 1 SCREEN 0 EI
                db      $9F, 1, $00, $00, $00, 0, 0, 0, 0   ; CHGET n 1 codes 00 off 0 CSRSW 0 SCREEN 0
                db      $9F, 1, $01, $00, $00, 0, 0, 0, 0   ; CHGET n 1 codes 01 off 0 CSRSW 0 SCREEN 0
                db      $9F, 1, $20, $00, $00, 0, 0, 0, 0   ; CHGET n 1 codes 20 off 0 CSRSW 0 SCREEN 0
                db      $9F, 1, $7F, $00, $00, 0, 0, 0, 0   ; CHGET n 1 codes 7F off 0 CSRSW 0 SCREEN 0
                db      $9F, 1, $FF, $00, $00, 0, 0, 0, 0   ; CHGET n 1 codes FF off 0 CSRSW 0 SCREEN 0
                db      $9F, 1, $42, $00, $00, 39, 0, 0, 0   ; CHGET n 1 codes 42 off 39 CSRSW 0 SCREEN 0
                db      $9F, 2, $43, $44, $00, 39, 0, 0, 0   ; CHGET n 2 codes 43 44 off 39 CSRSW 0 SCREEN 0
                db      $9F, 3, $41, $42, $43, 10, 0, 0, 0   ; CHGET n 3 codes 41 42 43 off 10 CSRSW 0 SCREEN 0
                db      $9F, 1, $41, $00, $00, 0, 1, 2, 0   ; CHGET n 1 codes 41 off 0 CSRSW 1 SCREEN 2
                db      $9C, 0, $00, $00, $00, 0, 0, 0, 0   ; CHSNS n 0 codes - off 0 CSRSW 0 SCREEN 0
                db      $9C, 0, $00, $00, $00, 39, 1, 0, 0   ; CHSNS n 0 codes - off 39 CSRSW 1 SCREEN 0
                db      $9C, 1, $41, $00, $00, 0, 0, 0, 0   ; CHSNS n 1 codes 41 off 0 CSRSW 0 SCREEN 0
                db      $9C, 1, $00, $00, $00, 0, 0, 0, 0   ; CHSNS n 1 codes 00 off 0 CSRSW 0 SCREEN 0
                db      $9C, 3, $41, $42, $43, 38, 0, 0, 0   ; CHSNS n 3 codes 41 42 43 off 38 CSRSW 0 SCREEN 0
                db      $9C, 1, $41, $00, $00, 0, 1, 0, 1   ; CHSNS n 1 codes 41 off 0 CSRSW 1 SCREEN 0 EI
                db      $9C, 0, $00, $00, $00, 0, 0, 2, 0   ; CHSNS n 0 codes - off 0 CSRSW 0 SCREEN 2
                db      $9C, 1, $41, $00, $00, 0, 0, 2, 0   ; CHSNS n 1 codes 41 off 0 CSRSW 0 SCREEN 2
                db      $FF
