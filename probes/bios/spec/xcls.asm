; Copyright (c) 2026 Joost Yervante Damad
; SPDX-License-Identifier: 0BSD
;
; XCLS -- docs/bios/CLS.md round 1 (2026-11-17): CLS ($00C3) and POSIT ($00C6) on the VG-8020 against zerobas.
; The CASE TABLE at the end is GENERATED by probes/bios/spec/xcls_cases.py (--gen), whose docstring documents the
; separating setup and the 159-byte record; the same module decodes the run.
; Run: python3 -u probes/bios/biosl_run.py probes/bios/spec/xcls.asm --row nodisk
; The capture: CAP+1 = $A5 when finished; records from CAP+2.
;
; CLEAN-ROOM: 100% own code; only published BIOS entries and work-area cells; VRAM through RDVRM / FILVRM.
;
; @cap C000
; @caplen 183B
; @timeout 300

RDVRM   equ     $004A
FILVRM  equ     $0056
INITXT  equ     $006C
INIT32  equ     $006F
INIGRP  equ     $0072
LINL40  equ     $F3AE
LINL32  equ     $F3AF
LINLEN  equ     $F3B0
CRTCNT  equ     $F3B1
CSRY    equ     $F3DC
CSRX    equ     $F3DD
CNSDFG  equ     $F3DE
SCRMOD  equ     $FCAF
FNKSTR  equ     $F87F
FORCLR  equ     $F3E9
LINTTB  equ     $FBB2

DONE    equ     $C000
CAP     equ     $C001
CAPLEN  equ     6203
ptr     equ     $EF00
tptr    equ     $EF02
ccall   equ     $EF04
cmode   equ     $EF05
cwidth  equ     $EF06
ccns    equ     $EF07
ccrt    equ     $EF08
czf     equ     $EF09
ch      equ     $EF0A
cl      equ     $EF0B
ccol    equ     $EF0C
nbase   equ     $EF10
ncols   equ     $EF12
jpstub  equ     $EF20

                org     $4000
                db      "AB"
                dw      init, 0, 0, 0
                ds      6, 0

init:
                ld      hl, CAP
                ld      de, CAP+1
                ld      bc, CAPLEN - 1
                ld      (hl), 0
                ldir
                ld      hl, CAP+2
                ld      (ptr), hl
                ld      hl, cases
                ld      (tptr), hl
next:
                ld      hl, (tptr)
                ld      a, (hl)
                cp      $FF
                jp      z, finish
                ld      de, ccall
                ld      bc, 9
                ldir
                ld      (tptr), hl
                ; the screen, key line off: INITXT / INIT32 / INIGRP
                xor     a
                ld      (CNSDFG), a
                ld      a, 24
                ld      (CRTCNT), a
                ld      a, (cwidth)
                ld      (LINL40), a
                ld      (LINL32), a
                ld      a, (cmode)
                or      a
                jr      nz, m_1
                call    INITXT
                ld      hl, 0
                ld      a, 40
                jr      m_done
m_1:
                cp      1
                jr      nz, m_2
                call    INIT32
                jr      m_32
m_2:
                call    INIGRP
m_32:
                ld      hl, $1800
                ld      a, 32
m_done:
                ld      (nbase), hl
                ld      (ncols), a
                ; separate LINLEN from the width cells
                ld      a, 77
                ld      (LINL40), a
                ld      (LINL32), a
                ld      hl, keys
                ld      de, FNKSTR
                ld      bc, 160
                ldir
                ld      hl, colours
                ld      a, (ccol)
                or      a
                jr      z, c_def
                ld      hl, colours2
c_def:
                ld      de, FORCLR
                ld      bc, 3
                ldir
                ld      a, (ccrt)
                ld      (CRTCNT), a
                ld      a, (ccns)
                ld      (CNSDFG), a
                ; garbage: all of VRAM, LINTTB, the cursor
                ld      hl, 0
                ld      bc, $4000
                ld      a, $5A
                call    FILVRM
                ld      hl, LINTTB
                ld      b, 24
g_lt:
                ld      (hl), $55
                inc     hl
                djnz    g_lt
                ld      a, 7
                ld      (CSRX), a
                ld      a, 5
                ld      (CSRY), a
                ; the call under test through a RAM JP: H / L the case's, the Z flag by cp
                ld      a, $C3
                ld      (jpstub), a
                ld      a, (ccall)
                ld      (jpstub+1), a
                xor     a
                ld      (jpstub+2), a
                ld      a, (ch)
                ld      h, a
                ld      a, (cl)
                ld      l, a
                ld      a, (czf)
                cp      1                       ; Z set when zf = 1
                call    jpstub
                ; the record
                ld      a, (CNSDFG)
                call    emit
                ld      a, (CRTCNT)
                call    emit
                ld      a, (CSRX)
                call    emit
                ld      a, (CSRY)
                call    emit
                ld      a, (LINLEN)
                call    emit
                ld      a, (SCRMOD)
                call    emit
                ld      hl, LINTTB
                ld      b, 24
r_lt:
                ld      a, (hl)
                call    emit
                inc     hl
                djnz    r_lt
                ld      hl, (nbase)
                ld      bc, 960
                ld      a, (ncols)
                cp      40
                jr      z, r_nb
                ld      bc, 768
r_nb:
                call    vsum
                ld      a, 1
                call    row40
                ld      a, (ccrt)
                call    row40
                ld      a, 24
                call    row40
                ld      hl, 0
                ld      bc, $0800
                call    vsum
                ld      hl, $2000
                ld      bc, $0800
                call    vsum
                ld      hl, 0
                ld      bc, $4000
                call    vsum
                ld      a, $C3                  ; the record's sentinel
                call    emit
                jp      next

finish:
                ld      a, $A5
                ld      (CAP+1), a
                ld      (DONE), a
halt_lp:
                jr      halt_lp

jphl:
                jp      (hl)

; row40 -- emit 40 VRAM cells from the start of row A (1-based): nbase + (A-1) x ncols
row40:
                ld      hl, (nbase)
                ld      b, a
                dec     b
                jr      z, rw_go
                push    hl
                ld      a, (ncols)
                ld      e, a
                ld      d, 0
                pop     hl
rw_mul:
                add     hl, de
                djnz    rw_mul
rw_go:
                ld      b, 40
rw_lp:
                push    bc
                push    hl
                call    RDVRM
                call    emit
                pop     hl
                pop     bc
                inc     hl
                djnz    rw_lp
                ret

; vsum -- emit sum16 (low, high) of BC VRAM bytes from HL
vsum:
                ld      de, 0
vs_lp:
                push    bc
                push    de
                push    hl
                call    RDVRM
                pop     hl
                pop     de
                add     a, e
                ld      e, a
                jr      nc, vs_nc
                inc     d
vs_nc:
                pop     bc
                inc     hl
                dec     bc
                ld      a, b
                or      c
                jr      nz, vs_lp
                ld      a, e
                call    emit
                ld      a, d
                jp      emit

emit:
                push    hl
                ld      hl, (ptr)
                ld      (hl), a
                inc     hl
                ld      (ptr), hl
                pop     hl
                ret

keys:
                db      "key0", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key1", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key2", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key3", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key4", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key5", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key6", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key7", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key8", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key9", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
colours:        db      11, 6, 13
colours2:       db      $3A, $C5, $F9

; ---- GENERATED by xcls_cases.py --gen: call, mode, width, CNSDFG, CRTCNT, zf, H, L, colours; $FF ends ----
cases:
                db      $C3, 0, 40, 0, 24, 1, 99, 99, 0   ; CLS SCREEN 0 width 40 CNSDFG 0 CRTCNT 24 Z set
                db      $C3, 0, 40, 0, 24, 0, 99, 99, 0   ; CLS SCREEN 0 width 40 CNSDFG 0 CRTCNT 24 Z clear
                db      $C3, 0, 40, 1, 24, 1, 99, 99, 0   ; CLS SCREEN 0 width 40 CNSDFG 1 CRTCNT 24 Z set
                db      $C3, 0, 40, 1, 24, 0, 99, 99, 0   ; CLS SCREEN 0 width 40 CNSDFG 1 CRTCNT 24 Z clear
                db      $C3, 0, 37, 1, 24, 1, 99, 99, 0   ; CLS SCREEN 0 width 37 CNSDFG 1 CRTCNT 24 Z set
                db      $C3, 0, 39, 0, 24, 1, 99, 99, 0   ; CLS SCREEN 0 width 39 CNSDFG 0 CRTCNT 24 Z set
                db      $C3, 0, 40, 0, 13, 1, 99, 99, 0   ; CLS SCREEN 0 width 40 CNSDFG 0 CRTCNT 13 Z set
                db      $C3, 1, 32, 0, 24, 1, 99, 99, 0   ; CLS SCREEN 1 width 32 CNSDFG 0 CRTCNT 24 Z set
                db      $C3, 0, 40, 1, 13, 1, 99, 99, 0   ; CLS SCREEN 0 width 40 CNSDFG 1 CRTCNT 13 Z set
                db      $C3, 1, 32, 1, 24, 1, 99, 99, 0   ; CLS SCREEN 1 width 32 CNSDFG 1 CRTCNT 24 Z set
                db      $C3, 1, 29, 1, 24, 1, 99, 99, 0   ; CLS SCREEN 1 width 29 CNSDFG 1 CRTCNT 24 Z set
                db      $C3, 1, 32, 0, 24, 0, 99, 99, 0   ; CLS SCREEN 1 width 32 CNSDFG 0 CRTCNT 24 Z clear
                db      $C3, 2, 32, 0, 24, 1, 99, 99, 0   ; CLS SCREEN 2 width 32 CNSDFG 0 CRTCNT 24 Z set
                db      $C3, 2, 32, 0, 24, 0, 99, 99, 0   ; CLS SCREEN 2 width 32 CNSDFG 0 CRTCNT 24 Z clear
                db      $C3, 2, 32, 1, 24, 1, 99, 99, 0   ; CLS SCREEN 2 width 32 CNSDFG 1 CRTCNT 24 Z set
                db      $C6, 0, 40, 0, 24, 1, 1, 1, 0   ; POSIT SCREEN 0 width 40 CNSDFG 0 CRTCNT 24 H 1 L 1
                db      $C6, 0, 40, 0, 24, 1, 40, 24, 0   ; POSIT SCREEN 0 width 40 CNSDFG 0 CRTCNT 24 H 40 L 24
                db      $C6, 0, 40, 0, 24, 1, 0, 0, 0   ; POSIT SCREEN 0 width 40 CNSDFG 0 CRTCNT 24 H 0 L 0
                db      $C6, 0, 40, 0, 24, 1, 41, 25, 0   ; POSIT SCREEN 0 width 40 CNSDFG 0 CRTCNT 24 H 41 L 25
                db      $C6, 0, 40, 0, 24, 1, 255, 255, 0   ; POSIT SCREEN 0 width 40 CNSDFG 0 CRTCNT 24 H 255 L 255
                db      $C6, 0, 40, 0, 24, 1, 20, 13, 0   ; POSIT SCREEN 0 width 40 CNSDFG 0 CRTCNT 24 H 20 L 13
                db      $C6, 0, 37, 0, 24, 1, 37, 24, 0   ; POSIT SCREEN 0 width 37 CNSDFG 0 CRTCNT 24 H 37 L 24
                db      $C6, 0, 37, 0, 24, 1, 38, 1, 0   ; POSIT SCREEN 0 width 37 CNSDFG 0 CRTCNT 24 H 38 L 1
                db      $C6, 1, 32, 0, 24, 1, 32, 24, 0   ; POSIT SCREEN 1 width 32 CNSDFG 0 CRTCNT 24 H 32 L 24
                db      $C6, 1, 32, 0, 24, 1, 33, 24, 0   ; POSIT SCREEN 1 width 32 CNSDFG 0 CRTCNT 24 H 33 L 24
                db      $C6, 2, 32, 0, 24, 1, 5, 5, 0   ; POSIT SCREEN 2 width 32 CNSDFG 0 CRTCNT 24 H 5 L 5
                db      $C6, 0, 40, 1, 24, 1, 1, 24, 0   ; POSIT SCREEN 0 width 40 CNSDFG 1 CRTCNT 24 H 1 L 24
                db      $C6, 0, 40, 0, 13, 1, 0, 0, 0   ; POSIT SCREEN 0 width 40 CNSDFG 0 CRTCNT 13 H 0 L 0
                db      $C6, 0, 40, 0, 13, 1, 20, 20, 0   ; POSIT SCREEN 0 width 40 CNSDFG 0 CRTCNT 13 H 20 L 20
                db      $C6, 0, 40, 0, 13, 1, 41, 14, 0   ; POSIT SCREEN 0 width 40 CNSDFG 0 CRTCNT 13 H 41 L 14
                db      $C6, 0, 40, 0, 13, 1, 39, 13, 0   ; POSIT SCREEN 0 width 40 CNSDFG 0 CRTCNT 13 H 39 L 13
                db      $C6, 0, 37, 0, 24, 1, 0, 30, 0   ; POSIT SCREEN 0 width 37 CNSDFG 0 CRTCNT 24 H 0 L 30
                db      $C6, 1, 29, 0, 24, 1, 31, 2, 0   ; POSIT SCREEN 1 width 29 CNSDFG 0 CRTCNT 24 H 31 L 2
                db      $C6, 1, 29, 0, 24, 1, 30, 24, 0   ; POSIT SCREEN 1 width 29 CNSDFG 0 CRTCNT 24 H 30 L 24
                db      $C6, 2, 32, 0, 24, 1, 3, 9, 0   ; POSIT SCREEN 2 width 32 CNSDFG 0 CRTCNT 24 H 3 L 9
                db      $C6, 2, 32, 0, 24, 1, 0, 0, 0   ; POSIT SCREEN 2 width 32 CNSDFG 0 CRTCNT 24 H 0 L 0
                db      $C3, 2, 32, 0, 24, 1, 99, 99, 1   ; CLS SCREEN 2 width 32 CNSDFG 0 CRTCNT 24 Z set colours 58,197,249
                db      $C3, 0, 40, 1, 24, 1, 99, 99, 1   ; CLS SCREEN 0 width 40 CNSDFG 1 CRTCNT 24 Z set colours 58,197,249
                db      $C3, 1, 32, 0, 24, 1, 99, 99, 1   ; CLS SCREEN 1 width 32 CNSDFG 0 CRTCNT 24 Z set colours 58,197,249
                db      $FF
