; Copyright (c) 2026 Joost Yervante Damad
; SPDX-License-Identifier: BSD-2-Clause
;
; XSCR -- docs/bios/DSPFNK.md and CLS.md round 2 (2026-11-17): DSPFNK / ERAFNK / FNKSB / CLS / POSIT on the VG-8020
; against zerobas, with every input at SEVERAL values (run 2: LINTTB's entries recorded, row 12 dropped:
; a capture reaching $F1A4 crashed the VG-8020 -- its stack at cartridge INIT lies below that). The CASE TABLE at the end is GENERATED by
; probes/bios/spec/xscr_cases.py (--gen), whose docstring documents the setup and the 209-byte record; the same
; module decodes the run. 209 bytes in run 1 (LINTTB as a sum), 191 in run 2.
; Run: python3 -u probes/bios/biosl_run.py probes/bios/spec/xscr.asm --row nodisk
; The capture: CAP+1 = $A5 when finished; records from CAP+2.
;
; CLEAN-ROOM: 100% own code; only published BIOS entries and work-area cells; VRAM through RDVRM / WRTVRM / FILVRM.
;
; @cap C000
; @caplen 290B
; @timeout 300

RDVRM   equ     $004A
WRTVRM  equ     $004D
FILVRM  equ     $0056
INITXT  equ     $006C
INIT32  equ     $006F
INIGRP  equ     $0072
INIMLT  equ     $0075
LINL40  equ     $F3AE
LINL32  equ     $F3AF
LINLEN  equ     $F3B0
CRTCNT  equ     $F3B1
TXTNAM  equ     $F3B3
T32NAM  equ     $F3BD
CSRY    equ     $F3DC
CSRX    equ     $F3DD
CNSDFG  equ     $F3DE
FORCLR  equ     $F3E9
SCRMOD  equ     $FCAF
LINTTB  equ     $FBB2
FNKSTR  equ     $F87F
FNKFLG  equ     $FBCE

DONE    equ     $C000
CAP     equ     $C001
CAPLEN  equ     10507
ptr     equ     $EF00
tptr    equ     $EF02
ccall   equ     $EF04                   ; the case's 16 bytes, in table order
cmode   equ     $EF05
cwidth  equ     $EF06
ccns    equ     $EF07
ccrt    equ     $EF08
ccsrx   equ     $EF09
ccsry   equ     $EF0A
cflg    equ     $EF0B
clab    equ     $EF0C
cnmv    equ     $EF0D
cgset   equ     $EF0E
ccol    equ     $EF0F
cea     equ     $EF10
cef     equ     $EF11
ch      equ     $EF12
cl      equ     $EF13
nbase   equ     $EF18
ncount  equ     $EF1A
ncols   equ     $EF1C
cfill   equ     $EF1D
jpstub  equ     $EF20
rA      equ     $EF24
rF      equ     $EF25

                org     $4000
                db      "AB"
                dw      init, 0, 0, 0
                ds      6, 0

init:
                ld      hl, CAP
                ld      de, CAP+1
                ld      bc, CAPLEN - 1
                ld      (hl), 0
                ldir
                ld      hl, CAP+2
                ld      (ptr), hl
                ld      hl, cases
                ld      (tptr), hl
next:
                ld      hl, (tptr)
                ld      a, (hl)
                cp      $FF
                jp      z, finish
                ld      de, ccall
                ld      bc, 16
                ldir
                ld      (tptr), hl
                ; the screen-table cells: defaults, or the name table moved
                ld      hl, tables
                ld      de, TXTNAM
                ld      bc, 20
                ldir
                ld      a, (cnmv)
                or      a
                jr      z, t_def
                ld      hl, $1000
                ld      (TXTNAM), hl
                ld      hl, $1C00
                ld      (T32NAM), hl
t_def:
                xor     a
                ld      (CNSDFG), a
                ld      a, 24
                ld      (CRTCNT), a
                ld      a, (cwidth)
                ld      (LINL40), a
                ld      (LINL32), a
                ; the colours
                ld      a, (ccol)
                ld      l, a
                add     a, a
                add     a, l                    ; x 3
                ld      e, a
                ld      d, 0
                ld      hl, colours
                add     hl, de
                ld      de, FORCLR
                ld      bc, 3
                ldir
                ; the mode, and where its name table is
                ld      a, (cmode)
                or      a
                jr      nz, m_1
                call    INITXT
                ld      hl, (TXTNAM)
                ld      bc, 960
                ld      a, 40
                jr      m_done
m_1:
                cp      1
                jr      nz, m_2
                call    INIT32
                ld      hl, (T32NAM)
                jr      m_768
m_2:
                cp      2
                jr      nz, m_3
                call    INIGRP
                ld      hl, $1800
                jr      m_768
m_3:
                call    INIMLT
                ld      hl, $0800
m_768:
                ld      bc, 768
                ld      a, 32
m_done:
                ld      (nbase), hl
                ld      (ncount), bc
                ld      (ncols), a
                ld      a, 77
                ld      (LINL40), a
                ld      (LINL32), a
                ; the labels: set clab (x 160)
                ld      a, (clab)
                ld      hl, labels
                ld      de, 160
                or      a
                jr      z, l_go
                ld      b, a
l_mul:
                add     hl, de
                djnz    l_mul
l_go:
                ld      de, FNKSTR
                ld      bc, 160
                ldir
                ld      hl, FNKFLG
                ld      a, (cflg)
                ld      b, 10
f_lp:
                ld      (hl), a
                inc     hl
                djnz    f_lp
                ld      a, (ccrt)
                ld      (CRTCNT), a
                ld      a, (ccns)
                ld      (CNSDFG), a
                ; garbage: all of VRAM, then the name table's address-dependent pattern
                ld      a, (cgset)
                or      a
                ld      a, $5A
                jr      z, g_f
                ld      a, $A5
g_f:
                ld      (cfill), a
                ld      hl, 0
                ld      bc, $4000
                call    FILVRM
                ld      a, (cgset)
                rrca
                rrca                            ; 0 or $40
                ld      e, a                    ; e = 64 x gset
                ld      hl, (nbase)
                ld      bc, (ncount)
                ld      d, 0                    ; d = i AND $FF
g_np:
                push    bc
                push    de
                push    hl
                ld      a, d
                add     a, e
                and     $7F
                or      $80
                call    WRTVRM
                pop     hl
                pop     de
                pop     bc
                inc     hl
                inc     d
                dec     bc
                ld      a, b
                or      c
                jr      nz, g_np
                ld      a, (cgset)
                or      a
                ld      a, $55
                jr      z, g_lt
                ld      a, $AA
g_lt:
                ld      hl, LINTTB
                ld      b, 24
g_ltl:
                ld      (hl), a
                inc     hl
                djnz    g_ltl
                ld      a, (ccsrx)
                ld      (CSRX), a
                ld      a, (ccsry)
                ld      (CSRY), a
                ; the call: HL := H / L, A / F := ea / ef
                ld      a, $C3
                ld      (jpstub), a
                ld      a, (ccall)
                ld      (jpstub+1), a
                xor     a
                ld      (jpstub+2), a
                ld      a, (cea)
                ld      d, a
                ld      a, (cef)
                ld      e, a
                ld      a, (ch)
                ld      h, a
                ld      a, (cl)
                ld      l, a
                push    de
                pop     af
                call    jpstub
                push    af
                pop     de
                ld      a, d
                ld      (rA), a
                ld      a, e
                ld      (rF), a
                ; the record
                ld      a, (rA)
                call    emit
                ld      a, (rF)
                call    emit
                ld      a, (CNSDFG)
                call    emit
                ld      a, (CRTCNT)
                call    emit
                ld      a, (CSRX)
                call    emit
                ld      a, (CSRY)
                call    emit
                ld      a, (LINLEN)
                call    emit
                ld      a, (SCRMOD)
                call    emit
                ld      a, (LINL40)
                call    emit
                ld      a, (LINL32)
                call    emit
                ld      hl, LINTTB              ; run 2: the 24 entries (run 1 kept only their sum)
                ld      b, 24
r_lt:
                ld      a, (hl)
                call    emit
                inc     hl
                djnz    r_lt
                ld      hl, (nbase)
                ld      bc, (ncount)
                call    vsum
                ld      a, 1
                call    row40
                ld      a, (ccrt)
                or      a
                jr      nz, r_c1
                inc     a
r_c1:
                cp      25
                jr      c, r_c2
                ld      a, 24
r_c2:
                call    row40
                ld      a, 24
                call    row40
                ld      hl, 0
                ld      bc, $4000
                call    vsum
                ; the SCREEN 2 / 3 windows
                ld      a, (cmode)
                cp      2
                jr      nc, w_rd
                ld      b, 32
w_ee:
                ld      a, $EE
                call    emit
                djnz    w_ee
                jr      w_done
w_rd:
                ld      hl, $0000
                call    win8
                ld      hl, $1000
                call    win8
                ld      hl, $2000
                call    win8
                ld      hl, $3000
                call    win8
w_done:
                ld      a, $C3                  ; the record's sentinel
                call    emit
                jp      next

finish:
                ld      a, $A5
                ld      (CAP+1), a
                ld      (DONE), a
halt_lp:
                jr      halt_lp

; win8 -- emit the 8 VRAM bytes from HL
win8:
                ld      b, 8
w8_lp:
                push    bc
                push    hl
                call    RDVRM
                call    emit
                pop     hl
                pop     bc
                inc     hl
                djnz    w8_lp
                ret

; row40 -- emit 40 VRAM cells from the start of row A (1-based): nbase + (A-1) x ncols
row40:
                ld      hl, (nbase)
                ld      b, a
                ld      a, (ncols)
                ld      e, a
                ld      d, 0
                dec     b
                jr      z, rw_go
rw_mul:
                add     hl, de
                djnz    rw_mul
rw_go:
                ld      b, 40
rw_lp:
                push    bc
                push    hl
                call    RDVRM
                call    emit
                pop     hl
                pop     bc
                inc     hl
                djnz    rw_lp
                ret

; vsum -- emit sum16 (low, high) of BC VRAM bytes from HL
vsum:
                ld      de, 0
vs_lp:
                push    bc
                push    de
                push    hl
                call    RDVRM
                pop     hl
                pop     de
                add     a, e
                ld      e, a
                jr      nc, vs_nc
                inc     d
vs_nc:
                pop     bc
                inc     hl
                dec     bc
                ld      a, b
                or      c
                jr      nz, vs_lp
                ld      a, e
                call    emit
                ld      a, d
                jp      emit

emit:
                push    hl
                ld      hl, (ptr)
                ld      (hl), a
                inc     hl
                ld      (ptr), hl
                pop     hl
                ret

; the screen-table cells' published defaults, TXTNAM .. T32PAT (10 words)
tables:         dw      $0000, $0000, $0800, $0000, $0000, $1800, $2000, $0000, $1B00, $3800
colours:        db      11, 6, 13, $3A, $C5, $F9, $1B, $16, $0D
; the label sets (160 B each), GENERATED below by xscr_cases.py from its LABELS

; ---- GENERATED by xscr_cases.py --gen: call, mode, width, cns, crt, csrx, csry, flg, lab, nmv, gset, col, ea, ef, h, l; $FF ends ----
labels:
; label set 0
                db      $6B, $65, $79, $30, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $31, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $32, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $33, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $34, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $35, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $36, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $37, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $38, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $39, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
; label set 1 (not used: zeros)
                db      $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
; label set 2
                db      $09, $61, $62, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $08, $63, $64, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $65, $66, $01, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $01, $61, $78, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $80, $FF, $7F, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $35, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $36, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $37, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $38, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $39, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
; label set 3
                db      $41, $42, $43, $44, $45, $46, $47, $48, $49, $4A, $4B, $4C, $4D, $4E, $4F, $50
                db      $7A, $7A, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $32, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $33, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $34, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $35, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $36, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $37, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $38, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
                db      $6B, $65, $79, $39, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00, $00
; label set 4
                db      $61, $62, $63, $64, $65, $66, $67, $68, $69, $6A, $6B, $6C, $6D, $6E, $30, $00
                db      $61, $62, $63, $64, $65, $66, $67, $68, $69, $6A, $6B, $6C, $6D, $6E, $31, $00
                db      $61, $62, $63, $64, $65, $66, $67, $68, $69, $6A, $6B, $6C, $6D, $6E, $32, $00
                db      $61, $62, $63, $64, $65, $66, $67, $68, $69, $6A, $6B, $6C, $6D, $6E, $33, $00
                db      $61, $62, $63, $64, $65, $66, $67, $68, $69, $6A, $6B, $6C, $6D, $6E, $34, $00
                db      $61, $62, $63, $64, $65, $66, $67, $68, $69, $6A, $6B, $6C, $6D, $6E, $35, $00
                db      $61, $62, $63, $64, $65, $66, $67, $68, $69, $6A, $6B, $6C, $6D, $6E, $36, $00
                db      $61, $62, $63, $64, $65, $66, $67, $68, $69, $6A, $6B, $6C, $6D, $6E, $37, $00
                db      $61, $62, $63, $64, $65, $66, $67, $68, $69, $6A, $6B, $6C, $6D, $6E, $38, $00
                db      $61, $62, $63, $64, $65, $66, $67, $68, $69, $6A, $6B, $6C, $6D, $6E, $39, $00
cases:
                db      $CF, $00, $28, $00, $18, $03, $18, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 3,24
                db      $CF, $00, $28, $00, $18, $14, $17, $00, $00, $00, $01, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 20,23 garbage 1
                db      $CC, $00, $28, $01, $18, $03, $18, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; ERAFNK SCREEN 0 w 40 CNSDFG 1 CRTCNT 24 cur 3,24
                db      $CC, $00, $28, $01, $18, $14, $17, $00, $00, $00, $01, $00, $01, $40, $63, $63   ; ERAFNK SCREEN 0 w 40 CNSDFG 1 CRTCNT 24 cur 20,23 garbage 1
                db      $C9, $00, $28, $01, $18, $03, $18, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; FNKSB SCREEN 0 w 40 CNSDFG 1 CRTCNT 24 cur 3,24
                db      $CF, $00, $28, $00, $18, $07, $05, $00, $00, $01, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 moved
                db      $CF, $01, $20, $00, $18, $07, $05, $00, $00, $01, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 1 w 32 CNSDFG 0 CRTCNT 24 cur 7,5 moved
                db      $CC, $00, $28, $01, $18, $07, $05, $00, $00, $01, $00, $00, $01, $40, $63, $63   ; ERAFNK SCREEN 0 w 40 CNSDFG 1 CRTCNT 24 cur 7,5 moved
                db      $CF, $00, $28, $FF, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 40 CNSDFG 255 CRTCNT 24 cur 7,5
                db      $CC, $00, $28, $FF, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; ERAFNK SCREEN 0 w 40 CNSDFG 255 CRTCNT 24 cur 7,5
                db      $C9, $00, $28, $FF, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; FNKSB SCREEN 0 w 40 CNSDFG 255 CRTCNT 24 cur 7,5
                db      $C9, $00, $28, $02, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; FNKSB SCREEN 0 w 40 CNSDFG 2 CRTCNT 24 cur 7,5
                db      $C9, $00, $28, $40, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; FNKSB SCREEN 0 w 40 CNSDFG 64 CRTCNT 24 cur 7,5
                db      $CF, $00, $21, $00, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 33 CNSDFG 0 CRTCNT 24 cur 7,5
                db      $CF, $00, $26, $00, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 38 CNSDFG 0 CRTCNT 24 cur 7,5
                db      $CF, $00, $1E, $00, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 30 CNSDFG 0 CRTCNT 24 cur 7,5
                db      $CF, $01, $1C, $00, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 1 w 28 CNSDFG 0 CRTCNT 24 cur 7,5
                db      $CF, $01, $1D, $00, $0D, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 1 w 29 CNSDFG 0 CRTCNT 13 cur 7,5
                db      $CF, $00, $25, $00, $0D, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 37 CNSDFG 0 CRTCNT 13 cur 7,5
                db      $CC, $01, $1D, $01, $0D, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; ERAFNK SCREEN 1 w 29 CNSDFG 1 CRTCNT 13 cur 7,5
                db      $CF, $00, $28, $00, $18, $07, $05, $00, $02, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 labels 2
                db      $CF, $00, $25, $00, $18, $07, $05, $00, $02, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 37 CNSDFG 0 CRTCNT 24 cur 7,5 labels 2
                db      $CF, $00, $28, $00, $18, $07, $05, $00, $03, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 labels 3
                db      $CF, $00, $28, $00, $18, $07, $05, $FF, $00, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 FNKFLG 255
                db      $CC, $00, $28, $01, $18, $07, $05, $FF, $00, $00, $00, $00, $01, $40, $63, $63   ; ERAFNK SCREEN 0 w 40 CNSDFG 1 CRTCNT 24 cur 7,5 FNKFLG 255
                db      $CF, $02, $20, $00, $18, $03, $09, $00, $00, $00, $01, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 2 w 32 CNSDFG 0 CRTCNT 24 cur 3,9 garbage 1
                db      $CC, $02, $20, $01, $18, $07, $05, $00, $00, $00, $01, $00, $01, $40, $63, $63   ; ERAFNK SCREEN 2 w 32 CNSDFG 1 CRTCNT 24 cur 7,5 garbage 1
                db      $C3, $00, $28, $00, $18, $07, $05, $00, $00, $00, $00, $00, $00, $40, $63, $63   ; CLS SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 A 00 F 40
                db      $C3, $00, $28, $00, $18, $07, $05, $00, $00, $00, $00, $00, $01, $00, $63, $63   ; CLS SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 A 01 F 00
                db      $C3, $00, $28, $00, $18, $07, $05, $00, $00, $00, $00, $00, $01, $41, $63, $63   ; CLS SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 A 01 F 41
                db      $C3, $00, $28, $00, $18, $07, $05, $00, $00, $00, $00, $00, $00, $00, $63, $63   ; CLS SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 A 00 F 00
                db      $C3, $00, $28, $02, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; CLS SCREEN 0 w 40 CNSDFG 2 CRTCNT 24 cur 7,5
                db      $C3, $00, $28, $80, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; CLS SCREEN 0 w 40 CNSDFG 128 CRTCNT 24 cur 7,5
                db      $C3, $00, $28, $FF, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; CLS SCREEN 0 w 40 CNSDFG 255 CRTCNT 24 cur 7,5
                db      $C3, $00, $28, $00, $18, $07, $05, $00, $00, $00, $01, $00, $01, $40, $63, $63   ; CLS SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 garbage 1
                db      $C3, $00, $28, $00, $18, $07, $05, $00, $00, $00, $01, $00, $01, $00, $63, $63   ; CLS SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 garbage 1 A 01 F 00
                db      $C3, $02, $20, $00, $18, $07, $05, $00, $00, $00, $00, $02, $01, $40, $63, $63   ; CLS SCREEN 2 w 32 CNSDFG 0 CRTCNT 24 cur 7,5 colours 2
                db      $C3, $02, $20, $00, $18, $07, $05, $00, $00, $00, $01, $01, $01, $40, $63, $63   ; CLS SCREEN 2 w 32 CNSDFG 0 CRTCNT 24 cur 7,5 garbage 1 colours 1
                db      $C3, $00, $28, $00, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $03, $09   ; CLS SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 H 3 L 9
                db      $C3, $00, $28, $00, $18, $07, $05, $00, $00, $01, $00, $00, $01, $40, $63, $63   ; CLS SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 moved
                db      $C3, $01, $20, $00, $18, $07, $05, $00, $00, $01, $00, $00, $01, $40, $63, $63   ; CLS SCREEN 1 w 32 CNSDFG 0 CRTCNT 24 cur 7,5 moved
                db      $C3, $01, $1D, $01, $0D, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; CLS SCREEN 1 w 29 CNSDFG 1 CRTCNT 13 cur 7,5
                db      $C3, $00, $28, $01, $18, $07, $05, $00, $04, $00, $00, $00, $01, $40, $63, $63   ; CLS SCREEN 0 w 40 CNSDFG 1 CRTCNT 24 cur 7,5 labels 4
                db      $C3, $03, $20, $00, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; CLS SCREEN 3 w 32 CNSDFG 0 CRTCNT 24 cur 7,5
                db      $C6, $00, $28, $00, $18, $07, $05, $00, $00, $00, $00, $00, $00, $00, $29, $1E   ; POSIT SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 7,5 A 00 F 00 H 41 L 30
                db      $C6, $00, $28, $01, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $05, $19   ; POSIT SCREEN 0 w 40 CNSDFG 1 CRTCNT 24 cur 7,5 H 5 L 25
                db      $C6, $00, $28, $01, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $05, $00   ; POSIT SCREEN 0 w 40 CNSDFG 1 CRTCNT 24 cur 7,5 H 5 L 0
                db      $C6, $03, $20, $00, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $03, $09   ; POSIT SCREEN 3 w 32 CNSDFG 0 CRTCNT 24 cur 7,5 H 3 L 9
                db      $C6, $02, $20, $00, $18, $0B, $03, $00, $00, $00, $01, $00, $01, $40, $03, $09   ; POSIT SCREEN 2 w 32 CNSDFG 0 CRTCNT 24 cur 11,3 garbage 1 H 3 L 9
                db      $C6, $00, $28, $00, $18, $0B, $03, $00, $00, $00, $01, $00, $01, $40, $05, $06   ; POSIT SCREEN 0 w 40 CNSDFG 0 CRTCNT 24 cur 11,3 garbage 1 H 5 L 6
                db      $C6, $00, $28, $FF, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $05, $19   ; POSIT SCREEN 0 w 40 CNSDFG 255 CRTCNT 24 cur 7,5 H 5 L 25
                db      $C6, $00, $28, $FF, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $05, $18   ; POSIT SCREEN 0 w 40 CNSDFG 255 CRTCNT 24 cur 7,5 H 5 L 24
                db      $C6, $00, $28, $FF, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $05, $17   ; POSIT SCREEN 0 w 40 CNSDFG 255 CRTCNT 24 cur 7,5 H 5 L 23
                db      $C6, $00, $28, $FF, $18, $07, $05, $00, $00, $00, $00, $00, $01, $40, $05, $00   ; POSIT SCREEN 0 w 40 CNSDFG 255 CRTCNT 24 cur 7,5 H 5 L 0
                db      $CF, $00, $28, $00, $0D, $05, $0D, $00, $00, $00, $00, $00, $01, $40, $63, $63   ; DSPFNK SCREEN 0 w 40 CNSDFG 0 CRTCNT 13 cur 5,13
                db      $FF
