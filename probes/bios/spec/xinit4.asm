; Copyright (c) 2026 Joost Yervante Damad
; SPDX-License-Identifier: 0BSD
;
; XINIT4 -- docs/bios/INITXT.md / INIT32.md round 4 (2026-11-17): XINIT3's probe with two more case fields, the VRAM
; garbage byte (`fill`) and the label set (`lab`), after the THIRD review (see xinit4_cases.py). XINIT3's header follows:
; XINIT3 -- docs/bios/INITXT.md / INIT32.md round 3 (2026-11-17): XINIT's supplement after the second review --
; register copies, CRTCNT and table cells at SEVERAL values, unmeasured widths, inputs read back, whole VRAM. The
; CASE TABLE at the end is GENERATED by probes/bios/spec/xinit4_cases.py (--gen), whose docstring documents the
; setup and the 231-byte record; the same module decodes the run.
; Run: python3 -u probes/bios/biosl_run.py probes/bios/spec/xinit4.asm --row nodisk
; The capture: CAP+0 LINLEN at INIT, +1 $A5 when finished, +2 CRTCNT, +3 CNSDFG at INIT; records from CAP+4.
;
; CLEAN-ROOM: 100% own code; only published BIOS entries and work-area cells; VRAM through RDVRM / FILVRM.
;
; @cap C000
; @caplen 1861
; @timeout 300

RDVRM   equ     $004A
FILVRM  equ     $0056
WRTVDP  equ     $0047
INIGRP  equ     $0072
LINL40  equ     $F3AE
LINL32  equ     $F3AF
LINLEN  equ     $F3B0
CRTCNT  equ     $F3B1
TXTNAM  equ     $F3B3
RG0SAV  equ     $F3DF
CSRY    equ     $F3DC
CSRX    equ     $F3DD
CNSDFG  equ     $F3DE
FORCLR  equ     $F3E9
SCRMOD  equ     $FCAF
LINTTB  equ     $FBB2
FNKSTR  equ     $F87F

DONE    equ     $C000
CAP     equ     $C001
CAPLEN  equ     6241
ptr     equ     $EF00
tptr    equ     $EF02
ccall   equ     $EF04
cwidth  equ     $EF05
ckey    equ     $EF06
cprior  equ     $EF07
cfg     equ     $EF08
cbg     equ     $EF09
cbd     equ     $EF0A
ctbl    equ     $EF0B
cvdp    equ     $EF0C
crgg    equ     $EF0D
ccrt    equ     $EF0E
cfill   equ     $EF0F
clab    equ     $EF10
rec0    equ     $EF10                   ; the record's start

                org     $4000
                db      "AB"
                dw      init, 0, 0, 0
                ds      6, 0

init:
                ld      hl, CAP
                ld      de, CAP+1
                ld      bc, CAPLEN - 1
                ld      (hl), 0
                ldir
                ld      a, (LINLEN)
                ld      (CAP+0), a
                ld      a, (CRTCNT)
                ld      (CAP+2), a
                ld      a, (CNSDFG)
                ld      (CAP+3), a
                ld      hl, CAP+4
                ld      (ptr), hl
                ld      hl, cases
                ld      (tptr), hl
next:
                ld      hl, (tptr)
                ld      a, (hl)
                cp      $FF
                jp      z, finish
                ld      de, ccall
                ld      bc, 13
                ldir
                ld      (tptr), hl
                ld      a, (cprior)
                or      a
                call    nz, INIGRP
                ; entry VDP state (cvdp): R0 := $02 (M3), R1 := $A0 (display OFF, IE0) through WRTVDP
                ld      a, (cvdp)
                or      a
                jr      z, no_vdp
                ld      bc, $0200
                call    WRTVDP
                ld      bc, $A001
                call    WRTVDP
no_vdp:
                ; the published inputs, written directly. The OTHER call's width gets 77, so a call that
                ; read the wrong cell shows it (round 1 kept LINL40 = LINL32)
                ld      a, 77
                ld      (LINL40), a
                ld      (LINL32), a
                ld      a, (ccall)
                cp      $6C
                ld      a, (cwidth)
                jr      nz, w_32
                ld      (LINL40), a
                jr      w_done
w_32:
                ld      (LINL32), a
w_done:
                ld      a, (ckey)
                ld      (CNSDFG), a
                ld      hl, cfg
                ld      de, FORCLR
                ld      bc, 3
                ldir
                ld      hl, tables
                ld      a, (ctbl)
                or      a
                jr      z, t_def
                ld      hl, tables2
                cp      1
                jr      z, t_def
                ld      hl, tables3
t_def:
                ld      de, TXTNAM
                ld      bc, 20
                ldir
                ; the function-key strings too: an INPUT of the key line (zerobas leaves FNKSTR empty at
                ; cartridge INIT, the VG-8020 has it filled -- XFNK; set it so the key row is INITXT's)
                ld      hl, keys
                ld      a, (clab)
                or      a
                jr      z, k_def
                ld      hl, keys7
k_def:
                ld      de, FNKSTR
                ld      bc, 160
                ldir
                ; garbage where the call should set things
                ld      a, 10
                ld      (CSRX), a
                ld      a, 5
                ld      (CSRY), a
                ld      a, 99
                ld      (LINLEN), a
                ld      a, (ccrt)
                ld      (CRTCNT), a
                ld      hl, RG0SAV              ; the register COPIES too (round 1 left them as found)
                ld      b, 8
                ld      a, (crgg)
gb_rg:
                ld      (hl), a
                inc     hl
                djnz    gb_rg
                ld      hl, LINTTB
                ld      b, 24
gb_lt:
                ld      (hl), $55
                inc     hl
                djnz    gb_lt
                ld      hl, 0
                ld      bc, $4000
                ld      a, (cfill)
                call    FILVRM
                ; the call under test
                ld      hl, (ccall)
                ld      h, 0
                call    jphl
                ; the record
                ld      hl, RG0SAV
                ld      b, 8
r_rg:
                ld      a, (hl)
                call    emit
                inc     hl
                djnz    r_rg
                ld      a, (SCRMOD)
                call    emit
                ld      a, (SCRMOD+1)
                call    emit
                ld      a, (LINLEN)
                call    emit
                ld      a, (CRTCNT)
                call    emit
                ld      a, (CSRX)
                call    emit
                ld      a, (CSRY)
                call    emit
                ld      a, (CNSDFG)
                call    emit
                ld      hl, LINTTB
                ld      b, 24
r_lt:
                ld      a, (hl)
                call    emit
                inc     hl
                djnz    r_lt
                ; the name table: RG2SAV x $400, 960 B (INITXT) / 768 B (INIT32)
                ld      a, (RG0SAV+2)
                and     $0F
                add     a, a
                add     a, a
                ld      h, a
                ld      l, 0
                ld      (nbase), hl
                ld      bc, 960
                ld      a, (ccall)
                cp      $6C
                jr      z, r_nb
                ld      bc, 768
r_nb:
                call    vsum
                ; the pattern table: RG4SAV x $800
                ld      a, (RG0SAV+4)
                and     $07
                add     a, a
                add     a, a
                add     a, a
                ld      h, a
                ld      l, 0
                ld      bc, 2048
                call    vsum
                ; the colour table: RG3SAV x $40, 32 B
                ld      a, (RG0SAV+3)
                ld      l, a
                ld      h, 0
                add     hl, hl
                add     hl, hl
                add     hl, hl
                add     hl, hl
                add     hl, hl
                add     hl, hl
                ld      bc, 32
                call    vsum
                ; the rest of the name table's 1 KB block: name + 960 / 768, 64 / 256 B
                ld      hl, (nbase)
                ld      de, 960
                ld      bc, 64
                ld      a, (ccall)
                cp      $6C
                jr      z, r_tl
                ld      de, 768
                ld      bc, 256
r_tl:
                add     hl, de
                call    vsum
                ; the sprite attribute table: RG5SAV x $80, 128 B
                ld      a, (RG0SAV+5)
                and     $7F
                ld      l, a
                ld      h, 0
                add     hl, hl
                add     hl, hl
                add     hl, hl
                add     hl, hl
                add     hl, hl
                add     hl, hl
                add     hl, hl
                ld      bc, 128
                call    vsum
                ; the last row's first 40 cells: name + 23 x 40 (INITXT) / 23 x 32 (INIT32)
                ld      hl, (nbase)
                ld      de, 920
                ld      a, (ccall)
                cp      $6C
                jr      z, r_kr
                ld      de, 736
r_kr:
                add     hl, de
                ld      b, 40
r_krl:
                push    bc
                push    hl
                call    RDVRM
                call    emit
                pop     hl
                pop     bc
                inc     hl
                djnz    r_krl
                ; row 13's first 40 cells (name + 12 x 40 / 12 x 32): the setup's CRTCNT is 13
                ld      hl, (nbase)
                ld      de, 480
                ld      a, (ccall)
                cp      $6C
                jr      z, r_13
                ld      de, 384
r_13:
                add     hl, de
                ld      b, 40
r_13l:
                push    bc
                push    hl
                call    RDVRM
                call    emit
                pop     hl
                pop     bc
                inc     hl
                djnz    r_13l
                ; row CRTCNT's first 40 cells, the row clamped to 1..24 for the read
                ld      a, (ccrt)
                or      a
                jr      nz, rc_1
                inc     a
rc_1:
                cp      25
                jr      c, rc_2
                ld      a, 24
rc_2:
                ld      hl, (nbase)
                ld      de, 40
                ld      b, a
                ld      a, (ccall)
                cp      $6C
                jr      z, rc_3
                ld      e, 32
rc_3:
                dec     b
                jr      z, rc_go
rc_mul:
                add     hl, de
                djnz    rc_mul
rc_go:
                ld      b, 40
rc_lp:
                push    bc
                push    hl
                call    RDVRM
                call    emit
                pop     hl
                pop     bc
                inc     hl
                djnz    rc_lp
                ; the input cells read back: LINL40, LINL32, FORCLR, BAKCLR, BDRCLR, TXTNAM .. T32PAT (20)
                ld      a, (LINL40)
                call    emit
                ld      a, (LINL32)
                call    emit
                ld      hl, FORCLR
                ld      b, 3
rb_c:
                ld      a, (hl)
                call    emit
                inc     hl
                djnz    rb_c
                ld      hl, TXTNAM
                ld      b, 20
rb_t:
                ld      a, (hl)
                call    emit
                inc     hl
                djnz    rb_t
                ; sum16 of FNKSTR (160 B, RAM)
                ld      hl, FNKSTR
                ld      de, 0
                ld      b, 160
fs_lp:
                ld      a, (hl)
                add     a, e
                ld      e, a
                jr      nc, fs_nc
                inc     d
fs_nc:
                inc     hl
                djnz    fs_lp
                ld      a, e
                call    emit
                ld      a, d
                call    emit
                ; sum16 of all 16 KB of VRAM
                ld      hl, 0
                ld      bc, $4000
                call    vsum
                ; the colour table's 32 bytes at RG3SAV x $40, byte for byte
                ld      a, (RG0SAV+3)
                ld      l, a
                ld      h, 0
                add     hl, hl
                add     hl, hl
                add     hl, hl
                add     hl, hl
                add     hl, hl
                add     hl, hl
                ld      b, 32
cb_lp:
                push    bc
                push    hl
                call    RDVRM
                call    emit
                pop     hl
                pop     bc
                inc     hl
                djnz    cb_lp
                ld      a, $C3                  ; the record's sentinel: a decoder refuses without it
                call    emit
                jp      next

finish:
                ld      a, $A5
                ld      (CAP+1), a
                ld      (DONE), a
halt_lp:
                jr      halt_lp

jphl:
                jp      (hl)

; vsum -- emit sum16 (low, high) of BC VRAM bytes from HL
vsum:
                ld      de, 0
vs_lp:
                push    bc
                push    de
                push    hl
                call    RDVRM
                pop     hl
                pop     de
                add     a, e
                ld      e, a
                jr      nc, vs_nc
                inc     d
vs_nc:
                pop     bc
                inc     hl
                dec     bc
                ld      a, b
                or      c
                jr      nz, vs_lp
                ld      a, e
                call    emit
                ld      a, d
                jp      emit

emit:
                push    hl
                ld      hl, (ptr)
                ld      (hl), a
                inc     hl
                ld      (ptr), hl
                pop     hl
                ret

nbase:          equ     $EF20
; the screen-table cells' published defaults, TXTNAM .. T32PAT (10 words)
tables:         dw      $0000, $0000, $0800, $0000, $0000, $1800, $2000, $0000, $1B00, $3800

; moved: TXTNAM $1000, TXTCOL $1234, TXTCGP $2800, TXTATR $3456, TXTPAT $3A00 (the last three are
; not INITXT's: does it touch them?), T32NAM $1C00, T32COL $2FC0, T32CGP $3000, T32ATR $1F80, T32PAT $0800
tables2:        dw      $1000, $1234, $2800, $3456, $3A00, $1C00, $2FC0, $3000, $1F80, $0800

; round 3: TXTCOL / TXTATR OUTSIDE every other table: $2000, $1800 (INITXT has none: are they written?)
tables3:        dw      $1000, $2000, $2800, $1800, $3A00, $1C00, $2FC0, $3000, $1F80, $0800

; 7-character labels (round 4): the cut to slot - 1 binds at every width
keys7:
                db      "ABCDEF0", 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "ABCDEF1", 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "ABCDEF2", 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "ABCDEF3", 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "ABCDEF4", 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "ABCDEF5", 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "ABCDEF6", 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "ABCDEF7", 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "ABCDEF8", 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "ABCDEF9", 0, 0, 0, 0, 0, 0, 0, 0, 0

keys:
                db      "key0", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key1", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key2", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key3", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key4", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key5", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key6", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key7", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key8", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0
                db      "key9", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0

; ---- GENERATED by xinit4_cases.py --gen: call, width, key, prior, fg, bg, bd, tbl, vdp, rgg, crt, fill, lab; $FF ends ----
cases:
                db      $6C, 40, 0, 0, 15, 4, 7, 0, 0, $01, 13, $5A, 0   ; INITXT width 40 key off copies $01 CRTCNT 13
                db      $6C, 40, 0, 0, 15, 4, 7, 0, 0, $04, 13, $5A, 0   ; INITXT width 40 key off copies $04 CRTCNT 13
                db      $6C, 40, 0, 0, 15, 4, 7, 0, 0, $20, 13, $5A, 0   ; INITXT width 40 key off copies $20 CRTCNT 13
                db      $6C, 40, 0, 0, 15, 4, 7, 0, 0, $80, 13, $5A, 0   ; INITXT width 40 key off copies $80 CRTCNT 13
                db      $6C, 40, 0, 0, 15, 4, 7, 0, 0, $FE, 13, $5A, 0   ; INITXT width 40 key off copies $FE CRTCNT 13
                db      $6C, 40, 0, 0, 15, 4, 7, 0, 0, $FB, 13, $5A, 0   ; INITXT width 40 key off copies $FB CRTCNT 13
                db      $6C, 40, 0, 0, 15, 4, 7, 0, 0, $DF, 13, $5A, 0   ; INITXT width 40 key off copies $DF CRTCNT 13
                db      $6C, 40, 0, 0, 15, 4, 7, 0, 0, $7F, 13, $5A, 0   ; INITXT width 40 key off copies $7F CRTCNT 13
                db      $6F, 32, 0, 0, 15, 4, 7, 0, 0, $01, 13, $5A, 0   ; INIT32 width 32 key off copies $01 CRTCNT 13
                db      $6F, 32, 0, 0, 15, 4, 7, 0, 0, $04, 13, $5A, 0   ; INIT32 width 32 key off copies $04 CRTCNT 13
                db      $6F, 32, 0, 0, 15, 4, 7, 0, 0, $20, 13, $5A, 0   ; INIT32 width 32 key off copies $20 CRTCNT 13
                db      $6F, 32, 0, 0, 15, 4, 7, 0, 0, $80, 13, $5A, 0   ; INIT32 width 32 key off copies $80 CRTCNT 13
                db      $6F, 32, 0, 0, 15, 4, 7, 0, 0, $FE, 13, $5A, 0   ; INIT32 width 32 key off copies $FE CRTCNT 13
                db      $6F, 32, 0, 0, 15, 4, 7, 0, 0, $FB, 13, $5A, 0   ; INIT32 width 32 key off copies $FB CRTCNT 13
                db      $6F, 32, 0, 0, 15, 4, 7, 0, 0, $DF, 13, $5A, 0   ; INIT32 width 32 key off copies $DF CRTCNT 13
                db      $6F, 32, 0, 0, 15, 4, 7, 0, 0, $7F, 13, $5A, 0   ; INIT32 width 32 key off copies $7F CRTCNT 13
                db      $6C, 0, 1, 0, 15, 4, 7, 0, 0, $A5, 13, $5A, 0   ; INITXT width 0 key on copies $A5 CRTCNT 13
                db      $6C, 80, 1, 0, 15, 4, 7, 0, 0, $A5, 13, $5A, 0   ; INITXT width 80 key on copies $A5 CRTCNT 13
                db      $6C, 255, 1, 0, 15, 4, 7, 0, 0, $A5, 13, $5A, 0   ; INITXT width 255 key on copies $A5 CRTCNT 13
                db      $6F, 0, 1, 0, 15, 4, 7, 0, 0, $A5, 13, $5A, 0   ; INIT32 width 0 key on copies $A5 CRTCNT 13
                db      $6F, 255, 1, 0, 15, 4, 7, 0, 0, $A5, 13, $5A, 0   ; INIT32 width 255 key on copies $A5 CRTCNT 13
                db      $6F, 32, 0, 0, 15, 4, 7, 1, 0, $A5, 13, $5A, 0   ; INIT32 width 32 key off copies $A5 CRTCNT 13 tables2
                db      $6F, 32, 1, 0, 15, 4, 7, 1, 0, $A5, 13, $5A, 0   ; INIT32 width 32 key on copies $A5 CRTCNT 13 tables2
                db      $6C, 40, 1, 0, 15, 4, 7, 0, 0, $A5, 13, $A3, 0   ; INITXT width 40 key on copies $A5 CRTCNT 13 fill A3
                db      $6F, 32, 1, 0, 15, 4, 7, 0, 0, $A5, 13, $A3, 0   ; INIT32 width 32 key on copies $A5 CRTCNT 13 fill A3
                db      $6C, 40, 1, 0, 15, 4, 7, 0, 0, $A5, 13, $5A, 1   ; INITXT width 40 key on copies $A5 CRTCNT 13 7-char labels
                db      $6F, 32, 1, 0, 15, 4, 7, 0, 0, $A5, 13, $5A, 1   ; INIT32 width 32 key on copies $A5 CRTCNT 13 7-char labels
                db      $FF
