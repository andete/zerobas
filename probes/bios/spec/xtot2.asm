; Copyright (c) 2026 Joost Yervante Damad
; SPDX-License-Identifier: BSD-2-Clause
;
; XTOT2 -- docs/bios/TOTEXT.md round 2 (2026-11-17): TOTEXT ($00D2) with OLDSCR, SCRMOD, the register copies, CRTCNT,
; CNSDFG and the colours at several values. The CASE TABLE at the end is GENERATED by probes/bios/spec/xtot2_cases.py
; (--gen), whose docstring documents the setup and the 30-byte record; the same module decodes the run.
; Run: python3 -u probes/bios/biosl_run.py probes/bios/spec/xtot2.asm --row nodisk
;
; CLEAN-ROOM: 100% own code; only published BIOS entries and work-area cells; VRAM through RDVRM / FILVRM.
;
; @cap C000
; @caplen 0200
; @timeout 120

RDVRM   equ     $004A
FILVRM  equ     $0056
INITXT  equ     $006C
INIT32  equ     $006F
INIGRP  equ     $0072
INIMLT  equ     $0075
TOTEXT  equ     $00D2
LINL40  equ     $F3AE
LINL32  equ     $F3AF
LINLEN  equ     $F3B0
CRTCNT  equ     $F3B1
RG0SAV  equ     $F3DF
CSRY    equ     $F3DC
CSRX    equ     $F3DD
CNSDFG  equ     $F3DE
FORCLR  equ     $F3E9
SCRMOD  equ     $FCAF
OLDSCR  equ     $FCB0

DONE    equ     $C000
CAP     equ     $C001
CAPLEN  equ     512
ptr     equ     $EF00
tptr    equ     $EF02
cmode   equ     $EF04                   ; the case's 10 bytes, in table order
cold    equ     $EF05
ccns    equ     $EF06
ccrt    equ     $EF07
cfg     equ     $EF08
cscr    equ     $EF0B
crg0    equ     $EF0C
crg1    equ     $EF0D

                org     $4000
                db      "AB"
                dw      init, 0, 0, 0
                ds      6, 0

init:
                ld      hl, CAP
                ld      de, CAP+1
                ld      bc, CAPLEN - 1
                ld      (hl), 0
                ldir
                ld      hl, CAP+2
                ld      (ptr), hl
                ld      hl, cases
                ld      (tptr), hl
next:
                ld      hl, (tptr)
                ld      a, (hl)
                cp      $FE
                jp      z, finish
                ld      de, cmode
                ld      bc, 10
                ldir
                ld      (tptr), hl
                xor     a
                ld      (CNSDFG), a
                ld      a, 40
                ld      (LINL40), a
                ld      a, 32
                ld      (LINL32), a
                ld      a, 24
                ld      (CRTCNT), a
                ld      hl, cfg
                ld      de, FORCLR
                ld      bc, 3
                ldir
                ld      a, (cmode)
                or      a
                jr      nz, m_1
                call    INITXT
                jr      m_done
m_1:
                cp      1
                jr      nz, m_2
                call    INIT32
                jr      m_done
m_2:
                cp      2
                jr      nz, m_3
                call    INIGRP
                jr      m_done
m_3:
                call    INIMLT
m_done:
                ld      a, (cscr)
                cp      $FF
                jr      z, s_1
                ld      (SCRMOD), a
s_1:
                ld      a, (crg0)
                cp      $FF
                jr      z, s_2
                ld      (RG0SAV), a
s_2:
                ld      a, (crg1)
                cp      $FF
                jr      z, s_3
                ld      (RG0SAV+1), a
s_3:
                ld      a, (cold)
                ld      (OLDSCR), a
                ld      a, 37
                ld      (LINL40), a
                ld      a, 29
                ld      (LINL32), a
                ld      a, 50
                ld      (LINLEN), a
                ld      a, (ccns)
                ld      (CNSDFG), a
                ld      a, (ccrt)
                ld      (CRTCNT), a
                ld      hl, 0
                ld      bc, $4000
                ld      a, $5A
                call    FILVRM
                ld      a, 7
                ld      (CSRX), a
                ld      a, 5
                ld      (CSRY), a
                call    TOTEXT
                ; the record
                ld      hl, RG0SAV
                ld      b, 8
r_rg:
                ld      a, (hl)
                call    emit
                inc     hl
                djnz    r_rg
                ld      a, (SCRMOD)
                call    emit
                ld      a, (OLDSCR)
                call    emit
                ld      a, (LINLEN)
                call    emit
                ld      a, (CRTCNT)
                call    emit
                ld      a, (CSRX)
                call    emit
                ld      a, (CSRY)
                call    emit
                ld      a, (CNSDFG)
                call    emit
                ; row CRTCNT's first 12 cells: SCREEN 1 after -> $1800 + (CRTCNT - 1) x 32, else (CRTCNT - 1) x 40
                ld      a, (ccrt)
                dec     a
                ld      b, a
                ld      hl, 0
                ld      de, 40
                ld      a, (SCRMOD)
                cp      1
                jr      nz, k_mul
                ld      hl, $1800
                ld      de, 32
k_mul:
                ld      a, b
                or      a
                jr      z, k_go
k_ml:
                add     hl, de
                djnz    k_ml
k_go:
                ld      b, 12
k_lp:
                push    bc
                push    hl
                call    RDVRM
                call    emit
                pop     hl
                pop     bc
                inc     hl
                djnz    k_lp
                ld      hl, 0
                ld      bc, $4000
                call    vsum
                ld      a, $C3
                call    emit
                jp      next

finish:
                ld      a, $A5
                ld      (CAP+1), a
                ld      (DONE), a
halt_lp:
                jr      halt_lp

; vsum -- emit sum16 (low, high) of BC VRAM bytes from HL
vsum:
                ld      de, 0
vs_lp:
                push    bc
                push    de
                push    hl
                call    RDVRM
                pop     hl
                pop     de
                add     a, e
                ld      e, a
                jr      nc, vs_nc
                inc     d
vs_nc:
                pop     bc
                inc     hl
                dec     bc
                ld      a, b
                or      c
                jr      nz, vs_lp
                ld      a, e
                call    emit
                ld      a, d
                jp      emit

emit:
                push    hl
                ld      hl, (ptr)
                ld      (hl), a
                inc     hl
                ld      (ptr), hl
                pop     hl
                ret

; ---- GENERATED by xtot2_cases.py --gen: mode, old, cns, crt, fg, bg, bd, scr, rg0, rg1; $FF ends ----
cases:
                db      0, $00, $00, 24, 15, 4, 4, $02, $FF, $FF   ; INITXT's copies, SCRMOD := 2, OLDSCR 0
                db      2, $01, $00, 24, 15, 4, 4, $00, $FF, $FF   ; INIGRP's copies, SCRMOD := 0, OLDSCR 1
                db      2, $00, $01, 13, 15, 4, 4, $FF, $FF, $FF   ; SCREEN 2 OLDSCR 0 CNSDFG 1 CRTCNT 13
                db      2, $01, $01, 13, 15, 4, 4, $FF, $FF, $FF   ; SCREEN 2 OLDSCR 1 CNSDFG 1 CRTCNT 13
                db      2, $00, $FF, 24, 15, 4, 4, $FF, $FF, $FF   ; SCREEN 2 OLDSCR 0 CNSDFG FF
                db      2, $00, $80, 24, 15, 4, 4, $FF, $FF, $FF   ; SCREEN 2 OLDSCR 0 CNSDFG 80
                db      2, $00, $00, 24, 3, 10, 9, $FF, $FF, $FF   ; SCREEN 2 OLDSCR 0 colours 3,10,9
                db      2, $01, $00, 24, 3, 10, 9, $FF, $FF, $FF   ; SCREEN 2 OLDSCR 1 colours 3,10,9
                db      2, $00, $00, 24, 15, 4, 4, $FF, $03, $E3   ; SCREEN 2 OLDSCR 0 RG0SAV 03 RG1SAV E3
                db      2, $01, $00, 24, 15, 4, 4, $FF, $03, $E3   ; SCREEN 2 OLDSCR 1 RG0SAV 03 RG1SAV E3
                db      2, $5A, $00, 24, 15, 4, 4, $FF, $FF, $FF   ; SCREEN 2 OLDSCR 5A (LINLEN preset 50)
                db      2, $02, $00, 24, 15, 4, 4, $FF, $FF, $FF   ; SCREEN 2 OLDSCR 02
                db      2, $03, $00, 24, 15, 4, 4, $FF, $FF, $FF   ; SCREEN 2 OLDSCR 03
                db      2, $7F, $00, 24, 15, 4, 4, $FF, $FF, $FF   ; SCREEN 2 OLDSCR 7F
                db      2, $80, $00, 24, 15, 4, 4, $FF, $FF, $FF   ; SCREEN 2 OLDSCR 80
                db      2, $81, $00, 24, 15, 4, 4, $FF, $FF, $FF   ; SCREEN 2 OLDSCR 81
                db      2, $FF, $00, 24, 15, 4, 4, $FF, $FF, $FF   ; SCREEN 2 OLDSCR FF
                db      $FE
